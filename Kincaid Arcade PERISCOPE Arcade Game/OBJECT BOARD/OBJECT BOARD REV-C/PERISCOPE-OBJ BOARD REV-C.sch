# EAGLE board PERISCOPE-OBJ BOARD REV-C (EAGLE 9.0.0), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$116  (via drill 0.35) (continued)
  Bottom 0.508: v207.01,68.71 153.67,68.71 153.67,67.18 147.96,61.47 102.23,61.47 99.19,64.52 (C9).12 | v210.82,54.99 225.3,54.99 227.2,56.9 (F9).6
N$119  (via drill 0.35)
  Top 0.508: v34.42,110.62 v34.42,133.1 35.56,134.24 v35.56,169.67
  Bottom 0.508: v34.42,110.62 30.61,110.62 (A11).9 | v34.42,133.1 30.61,133.1 (A12).9 | v35.56,169.67 67.56,169.67 67.56,171.96 68.33,172.72 (B14).6
N$120  (via drill 0.35)
  Top 0.508: v74.8,233.3 74.8,277.11 71.37,280.54 IC30.9 69.85,279.4 69.85,257.68 70.99,256.54 R87.1
  Bottom 0.508: (B16).12 65.66,233.3 v74.8,233.3
N$121
  Top 0.508: 68.71,256.54 72.52,252.73 72.52,242.82 61.09,231.39 (B16).13 | 68.71,256.54 68.71,272.92 IC30.7 | 68.71,256.54 R86.1
N$122  (via drill 0.35)
  Top 0.508: v76.71,234.44 77.09,234.82 v77.09,255.02 | R85.1 IC30.6
  Bottom 0.508: v76.71,234.44 61.47,234.44 58.42,231.39 (B16).14 | v77.09,255.02 67.56,255.02 R85.1
N$123  (via drill 0.35)
  Top 0.508: v47.37,252.73 v47.37,233.3 | IC30.5 63.75,272.92 63.75,256.54 R84.1
  Bottom 0.508: v47.37,233.3 53.85,233.3 55.75,231.39 (B16).15 | v47.37,252.73 47.75,253.11 59.94,253.11 63.37,256.54 R84.1
N$124  (via drill 0.35)
  Top 0.508: v45.09,253.87 v45.09,223.77 | IC30.4 61.09,272.92 61.09,256.54 R83.1
  Bottom 0.508: v45.09,223.77 53.09,223.77 (B16).1 | v45.09,253.87 58.04,253.87 60.71,256.54 R83.1
N$125  (via drill 0.35)
  Top 0.508: v49.66,255.02 v49.66,225.68 | R82.1 IC30.3
  Bottom 0.508: v49.66,225.68 53.85,225.68 55.75,223.77 (B16).2 | v49.66,255.02 56.9,255.02 R82.1
N$126  (via drill 0.35)
  Top 0.508: IC30.2 56.13,272.92 56.13,256.54 R81.1 | v48.51,258.06 v48.51,221.49
  Bottom 0.508: v48.51,221.49 56.52,221.49 58.42,223.39 (B16).3 | v48.51,258.06 54.23,258.06 55.75,256.54 R81.1
N$127  (via drill 0.35)
  Top 0.508: IC30.1 53.47,272.92 53.47,256.54 R80.1 | v46.23,256.54 v46.23,226.82
  Bottom 0.508: (B16).4 57.66,226.82 v46.23,226.82 | R80.1 v46.23,256.54
N$128
  Top 0.508: (A14).7 (A13).10
  Bottom 0.508: (A13).1 12.7,148.72 16.89,152.91 24.89,152.91 27.94,155.96 (A13).10 | (A14).7 26.03,174.62 14.6,174.62 (A14).1 R78.1
N$129
  Bottom 0.508: (C12).13 96.52,133.1 98.43,131.19 99.57,131.19 100.33,131.95 100.33,145.67 143.38,145.67 146.05,148.34 (D13).6
N$130  (via drill 0.35)
  Top 0.508: v34.42,156.34 v34.42,180.34
  Bottom 0.508: (B13).6 68.33,148.72 65.66,151.38 35.18,151.38 30.61,155.96 (A13).9 30.61,156.34 v34.42,156.34 | v34.42,180.34 (A14).9
N$131  (via drill 0.35)
  Top 0.508: (B14).13 62.23,176.53 v62.23,159.38 62.23,152.53 66.04,148.72 (B13).5
  Bottom 0.508: (A13).15 18.41,159.38 v62.23,159.38
N$132  (via drill 0.35)
  Top 0.508: v31.75,171.58 31.37,171.2 31.37,157.86 31.75,157.48 31.75,152.53 27.94,148.72 (A13).7
  Bottom 0.508: v31.75,171.58 31.75,173.86 30.23,175.39 20.32,175.39 15.37,180.34 (A14).15 | (B13).4 61.47,150.62 29.84,150.62 27.94,148.72 (A13).7
N$133
  Bottom 0.508: (B14).1 55.75,172.72 50.8,177.67 25.65,177.67 22.99,180.34 (A14).12
N$134  (via drill 0.35)
  Top 0.508: v218.82,227.58 218.44,227.2 218.44,202.06 214.63,198.25 (F15).1
  Bottom 0.508: (B16).5 67.56,227.58 147.57,227.58 147.96,227.2 186.82,227.2 187.2,227.58 v218.82,227.58
N$135
  Bottom 0.508: (A16).5 35.56,210.82 206.25,210.82 216.92,200.15 216.92,198.25 (F15).2
N$136
  Bottom 0.508: (B14).2 52.7,178.44 27.18,178.44 25.27,180.34 (A14).11
N$137  (via drill 0.35)
  Top 0.508: v31.75,124.33 31.75,106.81 27.94,103 (A11).7 | v60.71,158.24 60.71,172.72 (B14).3 | v17.27,154.05 16.51,153.29 16.51,134.62 (A12).15
  Bottom 0.508: v31.75,124.33 31.75,127 30.99,127.76 20.7,127.76 15.37,133.1 (A12).15 | v60.71,158.24 24.89,158.24 24.13,157.48 24.13,154.05 v17.27,154.05
N$138
  Bottom 0.508: (C14).1 93.85,172.72 88.9,177.67 63.75,177.67 61.09,180.34 (B14).12
N$139  (via drill 0.35)
  Top 0.508: 63.37,101.09 v62.23,99.95 | 63.37,101.09 63.37,102.62 (B11).4 | 63.37,101.09 63.37,100.71 69.09,100.71 69.85,101.47 69.85,112.52 62.23,120.14 62.23,131.95 61.09,133.1 (B12).12 | v48.51,170.81 48.51,147.19 48.13,146.81 48.13,135.76 v48.51,135.38
  Bottom 0.508: v62.23,99.95 24.89,99.95 24.51,99.57 23.75,99.57 23.37,99.95 16.51,99.95 16.51,109.09 15.37,110.24 (A11).15 | v48.51,170.81 61.47,170.81 63.37,172.72 (B14).4 | v48.51,135.38 58.8,135.38 60.71,133.48 (B12).12
N$140  (via drill 0.35)
  Top 0.508: (B12).1 56.13,125.86 58.42,128.14 (B12).13 58.42,137.29 60.71,139.57 R96.1 | v25.27,98.81 25.27,102.62 (A11).6 25.65,103 25.65,107.95 27.94,110.24 (A11).10 (A12).7 v27.94,130.05
  Bottom 0.508: (B12).1 58.04,123.57 61.47,123.57 63.37,125.48 (B12).4 | (A12).7 27.94,125.86 25.65,125.86 (A12).6 25.27,125.48 23.37,123.57 18.41,123.57 | 18.41,123.57 14.6,123.57 12.7,125.48 (A12).1 | 18.41,123.57 20.32,125.48 (A12).4 | v25.27,98.81 16.51,98.81 12.7,102.62 (A11).1 | v27.94,130.05 55.37,130.05 58.42,133.1 (B12).13
N$141  (via drill 0.35)
  Top 0.508: v125.86,44.7 v125.86,77.85 | v224.54,44.7 224.54,56.9 (F9).5
  Bottom 0.508: v125.86,77.85 108.71,77.85 106.81,79.76 (C10).6 | v224.54,44.7 v125.86,44.7
N$142
  Top 0.508: (C9).1 94.23,57.28 96.52,59.56 (C9).13 96.52,67.56 98.81,69.85 R100.1
  Bottom 0.508: (C9).1 96.14,54.99 99.57,54.99 101.47,56.9 (C9).4
N$143
  Top 0.508: (C10).12 101.09,89.66 109.09,89.66 109.09,87.76 (C10).8
N$144  (via drill 0.35)
  Top 0.508: v233.68,227.2 v233.68,256.54 233.68,257.68 235.97,259.97 235.97,279.78 230.63,279.78 229.87,280.54 IC44.9
  Bottom 0.508: v233.68,227.2 226.06,227.2 222.25,231.01 (F16).12 | R115.1 v233.68,256.54
N$145
  Bottom 0.508: (F15).4 222.25,198.25 218.44,202.06 218.44,217.3 256.54,217.3 261.49,222.25 261.49,223.39 (G16).5
N$146
  Top 0.508: (F15).5 226.06,199.39 226.06,207.01 224.92,208.15 224.92,220.73 222.25,223.39 (F16).5
N$147
  Bottom 0.508: (F15).9 229.49,203.58 261.11,203.58 266.45,198.25 (G15).6
N$148
  Bottom 0.508: (G15).3 258.83,198.25 254.25,202.82 227.58,202.82 224.92,205.49 (F15).10
N$149
  Bottom 0.508: (F15).6 227.58,198.25 229.49,200.15 254.64,200.15 256.54,198.25 (G15).2
N$150
  Top 0.508: (G16).12 270.64,240.16 270.64,255.4 269.49,256.54 R107.1 269.11,256.54 267.97,257.68 267.97,279.4 IC43.9
N$151  (via drill 0.35)
  Top 0.508: IC43.1 251.59,272.92 251.59,256.54 R53.1 | v259.21,244.73 259.21,231.39 (G16).13
  Bottom 0.508: v259.21,244.73 269.49,244.73 270.64,245.87 270.64,253.49 254.64,253.49 251.59,256.54 R53.1
N$152
  Top 0.508: IC43.2 254.25,272.92 254.25,256.54 R101.1 253.87,256.54 250.06,252.73 250.06,237.87 256.54,231.39 (G16).14
N$153
  Top 0.508: R102.1 IC43.3
  Bottom 0.508: (G16).15 259.21,236.35 259.21,243.59 269.49,243.59 271.4,245.49 271.4,254.25 258.83,254.25 R102.1
N$154  (via drill 0.35)
  Top 0.508: v247.78,271.02 v247.78,223.77 | R104.1 259.21,256.54 259.21,272.92 IC43.4
  Bottom 0.508: v247.78,223.77 251.21,223.77 (G16).1 | v247.78,271.02 256.92,271.02 258.83,272.92 IC43.4
N$155  (via drill 0.35)
  Top 0.508: v246.63,257.68 v246.63,225.3 | IC43.5 261.87,272.92 261.87,256.54 R103.1
  Bottom 0.508: v246.63,225.3 247.02,225.68 251.97,225.68 253.87,223.77 (G16).2 | v246.63,257.68 247.02,258.06 259.97,258.06 261.49,256.54 R103.1
N$156  (via drill 0.35)
  Top 0.508: v245.49,258.83 v245.49,226.44 | R105.1 IC43.6
  Bottom 0.508: v245.49,226.44 253.87,226.44 256.54,223.77 (G16).3 | v245.49,258.83 261.87,258.83 R105.1
N$157  (via drill 0.35)
  Top 0.508: v260.35,242.44 260.35,224.92 259.21,223.77 (G16).4 | IC43.7 266.83,272.92 266.83,256.54 R106.1
  Bottom 0.508: v260.35,242.44 260.73,242.82 269.88,242.82 272.16,245.11 272.16,255.02 268.35,255.02 266.83,256.54 R106.1
N$158  (via drill 0.35)
  Top 0.508: IC44.1 212.34,272.92 212.34,256.54 R108.1 | v207.39,234.44 207.01,234.82 v207.01,256.54
  Bottom 0.508: v207.39,234.44 216.53,234.44 219.58,231.39 (F16).13 | R108.1 v207.01,256.54
N$159  (via drill 0.35)
  Top 0.508: R109.1 IC44.2 | v206.25,229.11 206.25,255.78 205.87,256.16 v205.87,258.06
  Bottom 0.508: v206.25,229.11 215.01,229.11 216.92,231.01 (F16).14 | v205.87,258.06 213.11,258.06 R109.1
N$160  (via drill 0.35)
  Top 0.508: v208.15,233.3 208.53,233.68 208.53,254.64 v208.15,255.02 | IC44.3 217.3,272.92 217.3,256.54 R110.1
  Bottom 0.508: v208.15,233.3 212.72,233.3 214.63,231.39 (F16).15 | v208.15,255.02 215.39,255.02 216.92,256.54 R110.1
N$161  (via drill 0.35)
  Top 0.508: v207.01,226.44 205.11,228.35 v205.11,253.87 | IC44.4 219.96,272.92 219.96,256.54 R111.1
  Bottom 0.508: v207.01,226.44 209.3,226.44 211.96,223.77 (F16).1 | v205.11,253.87 216.92,253.87 219.58,256.54 R111.1
N$162  (via drill 0.35)
  Top 0.508: v234.82,255.02 v234.82,225.68 | R112.1 IC44.5
  Bottom 0.508: v234.82,225.68 216.53,225.68 214.63,223.77 (F16).2 | v234.82,255.02 223.77,255.02 R112.1
N$163  (via drill 0.35)
  Top 0.508: v218.44,244.73 218.44,229.87 217.68,229.11 217.68,224.16 217.3,223.77 (F16).3 | v235.97,244.73 235.97,257.68 v235.59,258.06 | IC44.6 224.92,272.92 224.92,256.54 R113.1
  Bottom 0.508: v235.97,244.73 v218.44,244.73 | v235.59,258.06 226.44,258.06 224.92,256.54 R113.1
N$164
  Top 0.508: (F16).4 226.06,229.87 226.06,240.54 231.39,245.87 231.39,252.73 227.58,256.54 | 227.58,256.54 227.58,272.92 IC44.7 | 227.58,256.54 R114.1
N$165  (via drill 0.35)
  Top 0.508: v164.34,46.99 v164.34,89.28 | (F9).4 v222.25,45.85
  Bottom 0.508: v164.34,89.28 163.96,89.66 103.76,89.66 101.85,87.76 (C10).11 | v164.34,46.99 191.01,46.99 192.53,45.47 221.87,45.47 v222.25,45.85
N$166  (via drill 0.35)
  Top 0.508: v22.99,31.75 22.99,58.42 (A9).4 | v233.68,64.52 v233.68,31.75
  Bottom 0.508: v233.68,31.75 v22.99,31.75 | v233.68,64.52 229.87,64.52 (F9).8
N$167
  Bottom 0.508: (C14).5 98.43,178.44 73.28,178.44 71.37,180.34 (B14).8
N$168
  Bottom 0.508: (D14).12 135.38,177.29 111.38,177.29 106.81,172.72 (C14).6
N$170
  Top 0.508: (G12).2 256.54,124.33 252.73,120.52 252.73,109.09 258.83,103 (G11).3
N$171  (via drill 0.35)
  Top 0.508: v125.48,183.39 v125.48,127.76
  Bottom 0.508: (C12).6 108.71,127.76 v125.48,127.76 | v125.48,183.39 125.86,183.01 143.38,183.01 (D14).9
N$172  (via drill 0.35)
  Top 0.508: v146.05,130.05 (D11).9
  Bottom 0.508: v146.05,130.05 104.9,130.05 (C12).11
N$173  (via drill 0.35)
  Top 0.508: (G10).15 254.25,87.76 260.35,93.85 260.35,109.09 259.21,110.24 (G11).12 | (G9).7 267.97,58.42 v267.97,77.09
  Bottom 0.508: v267.97,77.09 267.21,77.85 261.11,77.85 260.35,78.61 260.35,85.47 256.16,85.47 (G10).15
N$174
  Bottom 0.508: (D14).6 144.15,170.81 136.91,170.81 136.91,171.96 136.14,172.72 (D14).2
N$175
  Top 0.508: (B12).11 62.61,134.24 62.61,140.72 61.09,142.24 R117.1
  Bottom 0.508: (B12).8 69.09,135.38 65.66,135.38 63.75,133.48 (B12).11
N$176
  Top 0.508: (D13).11 141.1,156.34 141.1,172.72 (D14).4
N$177
  Top 0.508: (D14).5 143.76,172.72 144.53,171.96 144.53,160.15 148.34,156.34 (D13).8
N$179
  Top 0.508: (D14).1 133.48,172.72 139.19,178.44 148.34,178.44 148.34,180.34 (D14).8
N$187
  Top 0.508: R120.1 138.43,112.9 140.72,110.62 (D11).11
  Bottom 0.508: (D11).8 146.43,108.33 143,108.33 141.1,110.24 (D11).11
N$190
  Bottom 0.508: (C12).3 98.81,125.86 93.47,131.19 70.61,131.19 68.71,133.1 (B12).9
N$191
  Bottom 0.508: (B11).9 68.33,110.62 61.09,117.86 R122.1
N$192
  Top 0.508: 138.43,97.66 133.48,102.62 (D11).1 | R121.1 138.43,97.66 | (D11).4 138.43,100.33 138.43,97.66
  Bottom 0.508: 96.52,103 94.23,103 (C11).1 | 96.52,103 98.81,103 (C11).3 99.19,102.62 101.09,100.71 131.19,100.71 (D11).1 | 96.52,103 (C11).2
N$200
  Top 0.508: (E14).10 183.01,179.2 | 183.01,179.2 182.63,178.82 182.63,173.48 181.86,172.72 (E14).4 | R128.1 183.01,185.29 183.01,179.2
N$201
  Top 0.508: (E14).5 180.34,168.91 180.34,152.53 184.15,148.72 (E13).5
N$210  (via drill 0.35)
  Top 0.508: v167.77,182.63 v167.77,148.72
  Bottom 0.508: v167.77,148.72 173.86,148.72 (E13).1 | v167.77,182.63 184.53,182.63 186.82,180.34 (E14).9
N$212
  Bottom 0.508: (E13).4 181.86,148.72 186.44,153.29 197.1,153.29 213.87,170.05 218.06,170.05 219.58,171.58 219.58,172.72 (F14).3
N$213
  Bottom 0.508: (E13).2 176.53,148.72 181.86,154.05 196.72,154.05 213.49,170.81 217.68,170.81 218.44,171.58 218.44,174.62 225.3,174.62 227.2,172.72 (F14).6
OCEANCOLLISION  (via drill 0.35)
  Top 0.508: (G13).2 v256.54,134.24 | (G14).8 269.11,180.34 267.97,179.2 267.97,160.15 270.64,157.48 270.64,152.53 267.97,149.86 267.97,136.14 264.16,132.33 (G12).10
  Bottom 0.508: v256.54,134.24 262.25,134.24 264.16,132.33 (G12).10
OCEANV  (via drill 0.35)
  Top 0.508: JP71.1 216.15,3.94 216.15,6.22 JP71.2 216.15,6.6 216.15,8.89 | 216.15,8.89 216.15,11.18 JP71.4 216.15,11.56 216.15,13.84 JP71.5 216.15,14.22 216.15,16.51 JP71.6 215.77,16.51 209.68,22.61 209.68,48.89 204.72,53.85 v204.72,62.61 | 216.15,8.89 JP71.3 | v154.81,67.56 v154.81,128.91
  Bottom 0.508: v154.81,128.91 104.9,128.91 101.85,125.86 (C12).4 | v154.81,67.56 181.48,67.56 184.15,64.9 (E9).10 184.15,64.52 186.06,62.61 v204.72,62.61
OFLOOR  (via drill 0.35)
  Top 0.508: v252.35,162.43 252.35,136.53 256.54,132.33 (G12).13
  Bottom 0.508: v252.35,162.43 260.73,170.81 264.92,170.81 266.83,172.72 (G14).6
SA  (via drill 0.35)
  Top 0.508: v246.63,82.04 v246.63,121.28 v246.63,168.91 | v258.83,121.28 258.83,124.33 (G12).3 | v172.72,181.48 173.86,182.63 173.86,197.87 (E15).1 | v217.3,168.91 217.3,172.72 (F14).2
  Bottom 0.508: v246.63,82.04 254.64,82.04 256.54,80.14 (G10).3 | v258.83,121.28 v246.63,121.28 | 178.44,174.62 (E14).2 | 178.44,174.62 215.39,174.62 217.3,172.72 (F14).2 | (D15).9 146.05,205.49 144.15,203.58 138.81,203.58 (D15).1 133.48,197.87 135.38,195.96 171.96,195.96 173.86,197.87 (E15).1 | 178.44,174.62 174.62,178.44 173.48,178.44 172.72,179.2 v172.72,181.48 | v217.3,168.91 v246.63,168.91
SB  (via drill 0.35)
  Top 0.508: v250.83,120.14 250.83,104.9 252.73,103 252.73,86.23 258.83,80.14 (G10).4 | (E15).3 177.67,196.72 177.67,188.72 178.05,188.34 178.05,181.1 178.82,180.34 (E14).12 | v224.16,178.44 224.16,173.1 224.54,172.72 (F14).5 224.92,172.72 226.06,171.58 226.06,130.81 227.2,129.67 v227.2,127.38
  Bottom 0.508: v250.83,120.14 262.25,120.14 266.45,124.33 (G12).6 263.78,127.38 v227.2,127.38 | 141.48,200.15 138.05,200.15 136.14,198.25 (D15).2 | (D15).5 141.48,200.15 | v224.16,178.44 181.1,178.44 179.2,180.34 (E14).12 | 141.48,200.15 176.91,200.15 178.82,198.25 (E15).3
SQA  (via drill 0.35)
  Top 0.508: v234.82,194.82 v234.82,89.66
  Bottom 0.508: v234.82,89.66 254.64,89.66 256.54,87.76 (G10).14 | v234.82,194.82 234.44,195.2 186.82,195.2 184.15,197.87 (E15).5
SQB  (via drill 0.35)
  Top 0.508: v187.96,90.81 v187.96,107.57 187.96,204.34 186.82,205.49 (E15).9
  Bottom 0.508: v187.96,90.81 255.78,90.81 258.83,87.76 (G10).13 | (C11).11 104.52,107.57 v187.96,107.57
SQC  (via drill 0.35)
  Top 0.508: v194.06,203.58 v194.06,91.95
  Bottom 0.508: (G10).12 257.3,91.95 v194.06,91.95 | v194.06,203.58 183.77,203.58 (E15).11
SQD  (via drill 0.35)
  Top 0.508: v100.33,93.85 100.33,109.09 99.19,110.24 (C11).12 | v166.62,94.23 v166.62,203.58
  Bottom 0.508: v100.33,93.85 139.19,93.85 139.57,94.23 v166.62,94.23 257.68,94.23 264.16,87.76 (G10).11 | v166.62,203.58 174.62,203.58 176.53,205.49 (E15).13
STARTLINE  (via drill 0.35)
  Top 0.508: v116.33,150.62 v116.33,84.33 | v135.76,150.62 135.76,155.96 (D13).13
  Bottom 0.508: v116.33,84.33 107.19,84.33 104.14,87.38 (C10).10 | (C13).6 108.71,150.62 v116.33,150.62 v135.76,150.62
STOPDOWN  (via drill 0.35)
  Top 0.508: v267.97,100.71 267.97,125.86 261.87,131.95 (G12).11
  Bottom 0.508: v267.97,100.71 219.2,100.71 217.3,102.62 (F11).2
STOPUP  (via drill 0.35)
  Top 0.508: (F11).5 226.06,104.14 v226.06,128.91
  Bottom 0.508: v226.06,128.91 226.44,129.29 266.45,129.29 (G12).8
SUBEN
  Top 0.508: 258.83,154.05 258.83,155.96 (G13).12 | 258.83,154.05 258.83,153.29 254.25,148.72 (G13).1 | 258.83,154.05 267.21,154.05 269.11,155.96 (G13).8
SUBHEN  (via drill 0.35)
  Top 0.508: (F12).6 231.39,128.52 231.39,146.81 v231.01,147.19 | v141.48,144.53 141.48,147.96 141.1,148.34 (D13).4
  Bottom 0.508: 235.2,151.38 237.11,153.29 263.78,153.29 (G13).9 | 235.2,151.38 v231.01,147.19 | v141.48,144.53 141.86,144.91 208.53,144.91 215.01,151.38 235.2,151.38
SUBMARINE  (via drill 0.35)
  Top 0.508: JP54.1 139.95,3.94 139.95,6.22 JP54.2 139.95,6.6 139.95,8.89 | 139.95,8.89 139.95,11.18 JP54.4 139.95,11.56 139.95,13.84 JP54.5 139.95,14.22 139.95,16.51 JP54.6 | 139.95,8.89 JP54.3 | v235.97,19.94 v235.97,157.86
  Bottom 0.508: (G13).11 259.59,158.24 236.35,158.24 v235.97,157.86 | v235.97,19.94 235.59,19.56 143,19.56 139.95,16.51 JP54.6
SUBPROMDATA  (via drill 0.35)
  Top 0.508: v205.87,154.05 v205.87,209.68
  Bottom 0.508: v205.87,209.68 113.28,209.68 109.47,205.87 (C15).8 | v205.87,154.05 254.64,154.05 256.54,155.96 (G13).13
SUBVEN  (via drill 0.35)
  Top 0.508: (G9).15 253.87,64.52 251.97,62.61 247.4,62.61 247.4,78.99 247.78,79.38 v247.78,108.33 v247.78,160.15 | (C11).6 110.62,106.81 v110.62,114.05 | v264.16,160.15 (G13).10
  Bottom 0.508: (G11).13 256.54,110.24 254.64,108.33 v247.78,108.33 242.06,114.05 v110.62,114.05 | v247.78,160.15 v264.16,160.15
TA
  Bottom 0.508: (E13).6 183.77,145.67 166.24,145.67 157.86,154.05 143,154.05 142.24,154.81 142.24,161.29 29.08,161.29 17.65,172.72 (A14).3
TB
  Bottom 0.508: (E13).3 176.91,146.43 166.62,146.43 149.48,163.58 29.46,163.58 (A14).4
THA  (via drill 0.35)
  Top 0.508: v7.75,183.39 v7.75,128.91
  Bottom 0.508: (A12).3 14.6,128.91 v7.75,128.91 | v7.75,183.39 123.95,183.39 125.09,182.25 139.19,182.25 141.1,180.34 (D14).11
TORPEDO  (via drill 0.35)
  Top 0.508: 143.76,8.89 143.76,11.18 JP55.4 143.76,11.56 143.76,13.84 JP55.5 143.76,14.22 143.76,16.51 JP55.6 | v180.34,5.08 180.34,58.42 179.58,59.18 179.58,64.13 179.2,64.52 (E9).12 176.91,62.61 167.77,62.61 v167.77,117.09 | JP55.1 143.76,3.94 143.76,6.22 JP55.2 143.76,6.6 143.76,8.89 | 143.76,8.89 JP55.3 | (C12).5 v104.14,117.09 | v143.38,117.09 143.38,144.15 142.24,145.29 142.24,154.81 143.38,155.96 (D13).10
  Bottom 0.508: v180.34,5.08 144.91,5.08 143.76,6.22 JP55.2 | (B11).8 71.37,110.62 77.85,117.09 v104.14,117.09 v143.38,117.09 v167.77,117.09
TORPEDOHCORRECT  (via drill 0.35)
  Top 0.508: v144.91,105.66 142.24,108.33 v142.24,131.19 142.24,142.24 (D13).2
  Bottom 0.508: v144.91,105.66 144.91,104.14 143.76,103 (D11).5 | v142.24,131.19 108.71,131.19 106.81,133.1 (C12).9
TORPEDOHEN  (via drill 0.35)
  Top 0.508: (C12).12 92.71,127 v92.71,111.76
  Bottom 0.508: 62.99,108.33 61.09,110.24 (B11).12 | 62.99,108.33 68.33,103 (B11).6 | v92.71,111.76 89.28,108.33 62.99,108.33 | (D13).12 138.43,155.96 142.24,152.15 142.24,146.43 99.95,146.43 99.19,145.67 99.19,133.48 (C12).12
TORPEDOVCORRECT  (via drill 0.35)
  Top 0.508: v127,168.53 v127,148.72 126.62,148.34 v126.62,99.57
  Bottom 0.508: v127,168.53 26.42,168.53 26.42,171.96 25.65,172.72 (A14).6 | v127,148.72 133.1,148.72 (D13).1 | v126.62,99.57 135.38,99.57 138.43,102.62 (D11).3
TORPEDOVEN  (via drill 0.35)
  Top 0.508: (C11).5 v104.14,99.57 | v87.76,99.57 v87.76,170.81
  Bottom 0.508: v104.14,99.57 v87.76,99.57 64.14,99.57 62.61,101.09 62.23,101.09 62.23,106.43 58.42,110.24 (B11).13 | (C14).2 94.62,170.81 v87.76,170.81
TORPEDOVINCORRECT
  Bottom 0.508: (D11).2 133.86,104.9 103.76,104.9 101.85,103 (C11).4
UP  (via drill 0.35)
  Top 0.508: v142.24,219.2 142.24,202.06 138.43,198.25 (D15).3
  Bottom 0.508: v142.24,219.2 182.25,219.2 186.44,223.39 (E16).7
VCC  (via drill 0.35)
  Top 0.508: 248.92,87.76 251.21,87.76 (G10).16 | v249.3,110.62 248.92,110.62 | 248.92,132.33 253.87,132.33 (G12).14 | (G13).14 253.49,156.72 253.49,162.81 252.73,163.58 248.92,163.58 | 248.92,180.34 (G14).14 | 248.92,205.87 253.87,205.87 (G15).14 | 248.92,231.39 251.21,231.39 (G16).16 | R2.2 10.41,95.38 10.16,95.38 | 10.41,165.1 R78.2 | R121.2 128.52,95.38 128.27,95.38 | R120.2 128.52,122.05 128.27,122.05 | R1.2 209.68,163.96 209.55,163.96
  Top 1.016: (A9).14 10.16,66.04 10.16,87.63 | 10.16,87.63 R2.2 10.16,95.38 10.16,110.49 | 10.16,110.49 10.16,133.35 | 10.16,133.35 10.16,156.21 | 10.16,156.21 R78.2 10.16,180.34 | 10.16,180.34 10.16,190.5 | 10.16,190.5 10.16,231.14 | 10.16,231.14 10.16,246.38 | 10.16,246.38 10.16,280.67 IC31.16 | 10.16,246.38 R88.2 | (A16).16 10.16,231.14 | 10.16,190.5 25.4,190.5 (A15).5 | (A14).16 10.16,180.34 | (A13).16 10.16,156.21 | (A12).16 10.16,133.35 | (A11).16 10.16,110.49 | (A10).16 10.16,87.63 | (B10).16 50.8,87.63 50.8,110.49 | 50.8,110.49 R122.2 50.8,133.35 | 50.8,133.35 R96.2 R117.2 50.8,156.21 | 50.8,156.21 50.8,180.34 | 50.8,180.34 50.8,190.5 | 50.8,190.5 50.8,231.14 | 50.8,231.14 50.8,246.38 | 50.8,246.38 50.8,280.67 IC30.16 | 50.8,246.38 R80.2 | 50.8,231.14 (B16).16 | 50.8,190.5 66.04,190.5 (B15).5 | 50.8,180.34 (B14).14 | 50.8,156.21 (B13).14 | 50.8,133.35 (B12).14 | 50.8,110.49 (B11).14 | (C9).14 88.9,64.77 R100.2 R49.2 88.9,87.63 | 88.9,87.63 88.9,110.49 | 88.9,110.49 88.9,133.35 | 88.9,133.35 88.9,156.21 | 88.9,156.21 88.9,180.34 | 88.9,180.34 88.9,205.74 | 88.9,205.74 88.9,231.14 | 88.9,231.14 88.9,246.38 | 88.9,246.38 88.9,280.67 IC23.16 | 88.9,246.38 R70.2 | 88.9,231.14 (C16).16 | 88.9,205.74 (C15).14 | 88.9,180.34 (C14).14 | 88.9,156.21 (C13).14 | 88.9,133.35 (C12).14 | 88.9,110.49 (C11).14 | 88.9,87.63 (C10).14 | IC22.16 128.27,280.67 128.27,246.38 | 128.27,246.38 128.27,231.14 | 128.27,231.14 128.27,205.74 | 128.27,205.74 128.27,180.34 | 128.27,180.34 128.27,156.21 | 128.27,156.21 128.27,122.05 R120.2 128.27,110.49 | 128.27,110.49 128.27,95.38 R121.2 128.27,72.39 | 128.27,72.39 v128.27,49.53 | 128.27,72.39 143.51,72.39 (D10).5 | 128.27,110.49 (D11).14
  Top 1.016: 128.27,156.21 (D13).14 | 128.27,180.34 (D14).14 | 128.27,205.74 (D15).14 | 128.27,231.14 (D16).16 | 128.27,246.38 R62.2 | (E9).14 168.91,64.77 168.91,87.63 | 168.91,87.63 168.91,132.08 | 168.91,132.08 R48.2 168.91,156.21 | 168.91,156.21 168.91,180.34 | 168.91,180.34 R128.2 168.91,205.74 | 168.91,205.74 168.91,231.14 | 168.91,231.14 168.91,246.38 | 168.91,246.38 168.91,280.67 IC20.16 | 168.91,246.38 R54.2 | 168.91,231.14 (E16).16 | 168.91,205.74 (E15).14 | 168.91,180.34 (E14).14 | 168.91,156.21 (E13).14 | 168.91,132.08 (E12).14 | 168.91,87.63 (E10).14 | (F9).14 209.55,64.77 209.55,87.63 | 209.55,87.63 209.55,110.49 | 209.55,110.49 209.55,132.08 | 209.55,132.08 209.55,156.21 | 209.55,156.21 R1.2 209.55,163.96 209.55,180.34 | 209.55,180.34 209.55,205.74 | 209.55,205.74 209.55,231.14 | 209.55,231.14 209.55,246.38 | 209.55,246.38 209.55,280.67 IC44.16 | 209.55,87.63 (F10).14 | 209.55,110.49 (F11).14 | 209.55,132.08 (F12).14 | 209.55,156.21 (F13).14 | 209.55,180.34 (F14).14 | 209.55,205.74 (F15).14 | 209.55,231.14 (F16).16 | 209.55,246.38 R108.2 | IC43.16 248.92,280.67 248.92,231.39 248.92,205.87 248.92,180.34 248.92,163.58 248.92,132.33 248.92,110.62 248.92,87.76 R47.2 248.92,64.77 (G9).16
  Bottom 0.508: R3.2 193.29,46.99 | v249.3,110.62 253.87,110.62 (G11).14 | 208.53,49.53 208.53,46.99 R99.2 | 193.29,49.53 193.29,46.99 | 193.29,46.99 R4.2
  Bottom 1.016: R88.2 R89.2 R90.2 R91.2 R92.2 R93.2 R94.2 R95.2 R80.2 R81.2 R82.2 R83.2 R84.2 R85.2 R86.2 R87.2 R70.2 R71.2 R72.2 R73.2 R74.2 R75.2 R76.2 R77.2 R62.2 R63.2 R64.2 R65.2 R66.2 R67.2 R68.2 R69.2 R54.2 R55.2 R56.2 R57.2 R58.2 R59.2 R60.2 R61.2 R108.2 R109.2 R110.2 R111.2 R112.2 R113.2 R114.2 R115.2 R53.2 R101.2 R102.2 R104.2 R103.2 R105.2 R106.2 R107.2 | 248.92,49.53 248.92,64.77 (G9).16 | (F9).14 209.55,64.77 209.55,49.53 | (E9).14 168.91,64.77 168.91,49.53 | (D9).5 143.51,49.53 | (C9).14 88.9,64.77 88.9,49.53 | (B10).16 50.8,87.63 50.8,49.53 | (A9).14 10.16,66.04 10.16,49.53
  Bottom 2.54: JP72.P$1 10.16,49.53 50.8,49.53 88.9,49.53 v128.27,49.53 143.51,49.53 168.91,49.53 193.29,49.53 208.53,49.53 209.55,49.53 248.92,49.53
VISIBLE
  Top 0.508: (C9).2 96.52,57.28 101.85,62.61 107.95,62.61 107.95,75.95 104.14,79.76 (C10).5
  Bottom 0.508: (C10).2 96.52,79.76 98.43,77.85 102.23,77.85 104.14,79.76 (C10).5 | (E9).13 176.53,64.9 174.62,66.8 155.58,66.8 148.72,59.94 99.19,59.94 96.52,57.28 (C9).2
VISIBLETORPEDO  (via drill 0.35)
  Top 0.508: v46.23,122.81 v46.23,182.25 | v241.3,118.24 JP74.1
  Bottom 0.508: 59.56,122.81 59.56,119.76 | 59.56,119.76 59.56,117.09 66.04,110.62 (B11).10 | 59.56,122.81 63.37,122.81 66.04,125.48 (B12).5 | v46.23,182.25 61.47,182.25 63.37,180.34 (B14).11 | 59.56,122.81 v46.23,122.81 | v241.3,118.24 62.99,118.24 61.47,119.76 59.56,119.76
VRESET  (via drill 0.35)
  Top 0.508: JP36.1 106.81,3.94 106.81,6.22 JP36.2 106.81,6.6 106.81,8.89 | 106.81,8.89 106.81,11.18 JP36.4 106.81,11.56 106.81,13.84 JP36.5 106.81,14.22 106.81,16.51 JP36.6 | 106.81,8.89 JP36.3 | v186.82,82.04 186.82,87.38 (E10).9 | v226.06,20.7 226.06,63.37 227.2,64.52 (F9).9
  Bottom 0.508: (F9).9 219.2,72.9 219.2,77.85 218.44,78.61 218.44,82.04 v186.82,82.04 | v226.06,20.7 111,20.7 106.81,16.51 JP36.6

## Text on the board
Top: (c) KINCAIDARCADE 2018 | PERISCOPE - OBJ | REV - C | (A 15 Year Old!) | KincaidArcade.com | Engineered By: / Alexander H. | 18 | 17 | 16 | 15 | 14 | 13 | 12 | 11 | 10 | 9 | A | B | C | D | E | F | G | 49 | 15 | 20 | 26 | 39 | 1 | 10 | 27 | 36 | 53 | 59 | 62 | 71