# EAGLE board PERISCOPE REV - C (EAGLE 9.6.2), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$42  (via drill 0.35) (continued)
  Top 0.508: v152.27,265.56 v152.27,243.33 | L4.9 147.32,285.88 147.32,266.83 R25.1
  Bottom 0.508: J4.12 142.88,243.33 v152.27,243.33 | R25.1 v152.27,265.56
N$43
  Top 0.508: J4.13 149.99,252.98 149.99,261.62 R23.1 L4.7
N$44  (via drill 0.35)
  Top 0.508: v135.89,253.11 J4.14 | v143.51,256.92 R21.1 L4.6
  Bottom 0.508: v135.89,253.11 148.21,253.11 149.99,254.89 149.99,256.92 v143.51,256.92
N$45  (via drill 0.35)
  Top 0.508: v133.35,252.35 J4.15 | R19.1 L4.5
  Bottom 0.508: v133.35,252.35 133.22,252.48 129.54,252.48 127.89,254.13 127.89,262.51 137.92,262.51 R19.1
N$46  (via drill 0.35)
  Top 0.508: v125.35,264.16 v125.35,235.71 | R15.1 L4.3
  Bottom 0.508: J4.2 131.44,235.71 v125.35,235.71 | v125.35,264.16 134.49,264.16 R15.1
N$47  (via drill 0.35)
  Top 0.508: L4.2 R13.1 133.22,265.43 v133.22,257.81 | J4.3 134.62,235.08 v134.62,253.11
  Bottom 0.508: v134.62,253.11 134.49,253.24 129.92,253.24 128.65,254.51 128.65,257.81 v133.22,257.81
N$48  (via drill 0.35)
  Top 0.508: L4.1 R11.1 130.68,265.43 v130.68,256.92 | J4.4 137.16,235.08 v137.16,254
  Bottom 0.508: v137.16,254 130.3,254 129.41,254.89 129.41,256.92 v130.68,256.92
N$49  (via drill 0.35)
  Top 0.508: v154.05,235.71 v154.05,91.57
  Bottom 0.508: v154.05,91.57 D5.1 | v154.05,235.71 142.88,235.71 J4.5
N$50  (via drill 0.35)
  Top 0.508: v158.5,93.47 v158.5,231.01
  Bottom 0.508: J3.5 105.66,231.01 v158.5,231.01 | v158.5,93.47 172.09,93.47 D5.2
N$52  (via drill 0.35)
  Top 0.508: v274.07,231.9 v274.07,101.98
  Bottom 0.508: D5.4 184.78,97.28 202.69,97.28 207.39,101.98 v274.07,101.98 | v274.07,231.9 329.56,231.9 J9.5
N$53  (via drill 0.35)
  Top 0.508: v200.66,228.35 v200.66,94.36 | J8.5 v293.37,228.35
  Bottom 0.508: D5.5 184.4,94.36 v200.66,94.36 | v293.37,228.35 v200.66,228.35
N$54  (via drill 0.35)
  Top 0.508: I5.11 177.16,220.47 175.26,220.47 175.26,214.63 172.72,212.09 v172.72,157.1 | v178.18,157.1 178.31,156.97 178.31,150.62 182.88,146.05 182.88,100.46 D5.9
  Bottom 0.508: v178.18,157.1 v172.72,157.1
N$56  (via drill 0.35)
  Top 0.508: v195.58,220.34 195.71,220.22 v195.71,93.47
  Bottom 0.508: I5.10 183.51,220.47 195.45,220.47 v195.58,220.34 | v195.71,93.47 186.06,93.47 D5.6
N$58
  Top 0.508: D5.3 172.72,95.38 172.72,150.75 176.53,154.56 176.53,162.81 175.26,164.08 175.26,213.49 176.53,214.76 I5.12
N$59
  Top 0.508: B9.1 328.93,50.93 B9.12
N$60  (via drill 0.35)
  Top 0.508: A6.9 223.52,31.88 223.52,52.2 B6.9 | K1.8 33.02,263.02 v33.02,249.43 | v196.47,249.43 196.47,93.98 196.6,93.85 v196.6,56.26
  Bottom 0.508: v196.47,249.43 v33.02,249.43 | v196.6,56.26 196.72,56.13 222.12,56.13 B6.9
N$61  (via drill 0.35)
  Top 0.508: v304.67,265.56 v304.67,243.33 | L8.9 299.72,285.88 299.72,266.83 R42.1
  Bottom 0.508: J8.12 295.27,243.33 v304.67,243.33 | R42.1 v304.67,265.56
N$62
  Top 0.508: A9.1 328.93,28.07 A9.12
N$63  (via drill 0.35)
  Top 0.508: v209.55,43.81 A6.15 | K1.9 30.48,263.02 v30.48,248.54 | v156.72,43.94 v156.72,248.54
  Bottom 0.508: B6.7 220.34,43.94 209.68,43.94 v209.55,43.81 209.42,43.94 v156.72,43.94 | v156.72,248.54 v30.48,248.54
N$64
  Bottom 0.508: B7.8 264.8,51.56 321.94,51.56 B9.14
N$65  (via drill 0.35)
  Top 0.508: v342.77,265.56 v342.77,243.33 | L9.9 337.82,285.88 337.82,266.83 R41.1
  Bottom 0.508: J9.12 333.38,243.33 v342.77,243.33 | R41.1 v342.77,265.56
N$66  (via drill 0.35)
  Top 0.508: R27.1 L9.1 | v315.98,265.56 v315.98,243.33
  Bottom 0.508: J9.13 327.02,243.33 v315.98,243.33 | R27.1 v315.98,265.56
N$67
  Top 0.508: A9.14 335.28,42.04 335.28,49.66 B9.11
N$68  (via drill 0.35)
  Top 0.508: v295.15,49.53 298.45,52.83 B8.9
  Bottom 0.508: B4.3 142.11,49.53 v295.15,49.53
N$71  (via drill 0.35)
  Top 0.508: v97.79,169.54 G3.13 | v123.7,47.75 v123.7,169.54
  Bottom 0.508: v123.7,169.54 v97.79,169.54 | v123.7,47.75 133.99,47.75 B4.2 138.81,42.93 224.28,42.93 229.11,47.75 258.44,47.75 B7.6
N$72  (via drill 0.35)
  Top 0.508: L9.2 R29.1 323.72,265.43 v323.72,257.81 | v326.39,252.98 J9.14
  Bottom 0.508: v326.39,252.98 320.68,252.98 319.15,254.51 319.15,257.81 v323.72,257.81
N$73  (via drill 0.35)
  Top 0.508: v323.85,253.87 J9.15 | v326.39,256.92 R31.1 L9.3
  Bottom 0.508: v323.85,253.87 323.72,254 320.8,254 319.91,254.89 319.91,256.92 v326.39,256.92
N$74  (via drill 0.35)
  Top 0.508: v317.63,233.81 317.75,233.93 317.75,264.03 v317.63,264.16 | R33.1 L9.4
  Bottom 0.508: v317.63,233.81 J9.1 | v317.63,264.16 327.53,264.16 R33.1
N$75  (via drill 0.35)
  Top 0.508: v316.87,263.27 v316.87,235.71 | R35.1 L9.5
  Bottom 0.508: J9.2 321.94,235.71 v316.87,235.71 | v316.87,263.27 329.18,263.27 R35.1
N$76  (via drill 0.35)
  Top 0.508: J9.3 327.66,235.08 v327.66,254 | v334.01,256.92 R37.1 L9.6
  Bottom 0.508: v327.66,254 339.6,254 340.49,254.89 340.49,256.92 v334.01,256.92
N$77  (via drill 0.35)
  Top 0.508: J8.3 289.56,235.08 v289.56,254 | v295.91,256.92 R38.1 L8.6
  Bottom 0.508: v289.56,254 301.5,254 302.39,254.89 302.39,256.92 v295.91,256.92
N$80  (via drill 0.35)
  Top 0.508: C6.9 223.52,77.6 v223.52,94.49 | C8.11 294.64,77.6 v294.64,96.14
  Bottom 0.508: v223.52,94.49 224.79,95.76 224.79,96.14 | D6.9 224.79,96.14 | 224.79,96.14 v294.64,96.14
N$81
  Bottom 0.508: D7.8 264.8,101.09 286.38,101.09 D8.13
N$83  (via drill 0.35)
  Top 0.508: v89.03,82.3 v89.03,143 | v287.02,82.3 287.02,69.98 C8.2
  Bottom 0.508: F3.12 98.42,143 v89.03,143 | v287.02,82.3 v89.03,82.3
N$85
  Bottom 0.508: C7.4 C7.3
N$86  (via drill 0.35)
  Top 0.508: v126.36,105.28 v126.36,193.29 | v260.73,105.28 260.73,101.22 261.62,100.33 261.62,69.98 C7.6
  Bottom 0.508: H3.9 109.86,193.17 126.24,193.17 v126.36,193.29 | v260.73,105.28 v126.36,105.28
N$87
  Bottom 0.508: C8.3 292.74,70.61 324.49,70.61 C9.2
N$88  (via drill 0.35)
  Top 0.508: v306.45,277.62 v306.45,91.57
  Bottom 0.508: v306.45,91.57 D9.1 | v306.45,277.62 79.38,277.62 L2.9
N$89  (via drill 0.35)
  Top 0.508: v229.36,132.08 v229.36,95.25 | v96.52,131.95 96.52,143.64 F3.13
  Bottom 0.508: D9.4 327.79,95.25 v229.36,95.25 | v229.36,132.08 108.46,132.08 108.33,131.95 v96.52,131.95
N$93
  Top 0.508: I6.9 I6.3
N$94  (via drill 0.35)
  Top 0.508: v266.57,265.56 v266.57,243.33 | L7.9 261.62,285.88 261.62,266.83 R67.1
  Bottom 0.508: J7.12 257.18,243.33 v266.57,243.33 | R67.1 v266.57,265.56
N$95
  Top 0.508: R3.2 Q2.C
N$96
  Top 0.508: E1.12 29.21,116.97 E1.5
N$97
  Top 0.508: C1.12 29.21,71.25 C1.5
N$99  (via drill 0.35)
  Top 0.508: 20.19,115.57 21.59,116.97 E1.13 | 20.19,115.57 E1.1 | v20.32,78.99 20.32,115.44 20.19,115.57
  Bottom 0.508: 34.29,78.87 40.51,85.09 53.85,85.09 DD1.C | 34.29,78.87 C1.9 | v20.32,78.99 34.16,78.99 34.29,78.87
N$100  (via drill 0.35)
  Top 0.508: v82.68,179.07 v82.68,116.33
  Bottom 0.508: E1.4 28.57,116.33 v82.68,116.33 | v82.68,179.07 327.79,179.07 S1.2
N$101  (via drill 0.35)
  Top 0.508: 30.23,92.58 33.02,95.38 33.02,120.78 E1.8 | 30.23,92.58 D1.5 | v30.48,74.42 30.48,85.85 30.35,85.98 30.35,92.46 30.23,92.58
  Bottom 0.508: DD3.C 54.61,74.42 v30.48,74.42
N$102
  Top 0.508: R6.1 D1.6
N$103
  Top 0.508: 59.05,95.38 R4.2 | R3.1 59.05,95.38 | DD3.A 59.18,81.28 59.18,95.25 59.05,95.38
N$104  (via drill 0.35)
  Top 0.508: v114.17,91.57 v114.17,112.52 114.3,112.65 v114.3,148.59
  Bottom 0.508: E3.4 104.78,112.52 v114.17,112.52 | D3.4 v114.17,91.57 | F5.8 182.88,148.72 114.43,148.72 v114.3,148.59
N$105
  Top 0.508: T2.C 64.77,110.62 64.77,97.16 66.04,95.89 DD1.A
  Bottom 0.508: D1.9 33.66,97.28 53.98,97.28 64.14,87.12 DD1.A 66.17,87 69.34,87 R8.1
N$106
  Top 0.508: Q2.B CC3.2 64.01,98.04 64.01,96.77 64.9,95.89 64.9,88.14 64.52,87.76 64.52,82.55 R7.1 69.85,76.96 R8.2
N$107  (via drill 0.35)
  Top 0.508: R5.2 T1.C | T2.B CC4.1 63.37,105.41 v63.37,102.36
  Bottom 0.508: v63.37,102.36 R4.1 | R5.2 72.39,113.79 65.41,113.79 T2.B
N$108  (via drill 0.35)
  Top 0.508: F5.6 v184.15,125.48
  Bottom 0.508: E3.12 103.76,125.48 v184.15,125.48
N$109
  Bottom 0.508: CC6.1 68.71,100.58 109.09,100.58 D3.5
N$110
  Top 0.508: J3.13 111.89,252.98 111.89,261.62 R24.1 L3.7
N$111  (via drill 0.35)
  Top 0.508: v115.19,265.56 v115.19,244.73 | L3.9 109.22,285.88 109.22,266.83 R26.1
  Bottom 0.508: J3.12 106.17,244.73 v115.19,244.73 | R26.1 v115.19,265.56
N$112  (via drill 0.35)
  Top 0.508: v29.21,107.57 D1.10
  Bottom 0.508: v29.21,107.57 58.29,107.57 58.55,107.31 69.47,107.31 72.14,109.98 95.89,109.98 E3.3
N$114
  Bottom 0.508: D1.11 29.34,101.85 52.58,101.85 61.47,92.96 106.55,92.96 D3.3
N$115
  Bottom 0.508: E4.3 143.38,119.38 144.4,119.38 146.05,121.03 E4.9
N$116
  Top 0.508: CC5.+ 62.23,94.11 R10.2
  Bottom 0.508: D3.6 D3.7 101.6,95.38 CC5.+
N$117
  Top 0.508: E4.10 146.05,119.51 E4.6
N$118  (via drill 0.35)
  Top 0.508: v275.84,188.72 v275.84,88.9
  Bottom 0.508: R10.1 74.55,88.77 190.75,88.77 190.88,88.9 201.17,88.9 201.29,88.77 215.01,88.77 215.14,88.9 v275.84,88.9 | v275.84,188.72 328.42,188.72 330.2,190.5 VR2.2 330.33,190.63 VR2.3
N$119
  Bottom 0.508: D4.6 151,96.52 173.86,96.52 D5.12
N$121
  Top 0.508: E5.2 179.07,119.51 E5.11
N$122
  Bottom 0.508: E5.1 176.4,119.38 184.02,119.38 E5.8
N$124  (via drill 0.35)
  Top 0.508: v124.46,263.27 v124.46,233.81 | R17.1 L4.4
  Bottom 0.508: v124.46,233.81 J4.1 | v124.46,263.27 136.14,263.27 R17.1
N$125  (via drill 0.35)
  Top 0.508: B2.2 58.42,44.58 58.42,43.43 58.93,42.93 v61.85,42.93 | B3.12 95.25,48.39 B3.1
  Bottom 0.508: v61.85,42.93 62.87,43.94 93.34,43.94 B3.1
N$126
  Bottom 0.508: A1.8 35.31,31.62 55.75,31.62 56.64,32.51 57.78,32.51 A2.13
N$127  (via drill 0.35)
  Top 0.508: v46.23,18.41 v46.23,96.39 | A5.6 v184.15,18.41
  Bottom 0.508: D1.13 24.38,96.39 v46.23,96.39 | v184.15,18.41 v46.23,18.41
N$128
  Bottom 0.508: B2.5 69.6,50.67 105.16,50.67 B3.9
N$129  (via drill 0.35)
  Top 0.508: B3.8 v110.49,56.26
  Bottom 0.508: B2.11 69.98,56.13 110.36,56.13 v110.49,56.26
N$130  (via drill 0.35)
  Top 0.508: B3.11 v102.87,57.02
  Bottom 0.508: B2.14 63.25,57.02 v102.87,57.02
N$131  (via drill 0.35)
  Top 0.508: 67.31,43.81 v59.31,43.81 | B2.6 67.31,43.81 | v67.44,38.23 67.44,43.69 67.31,43.81
  Bottom 0.508: B1.2 23.62,43.81 v59.31,43.81 | A3.9 100.33,38.23 v67.44,38.23
N$132  (via drill 0.35)
  Top 0.508: v228.47,265.56 v228.47,243.33 | L6.9 223.52,285.88 223.52,266.83 R52.1
  Bottom 0.508: J6.12 219.07,243.33 v228.47,243.33 | R52.1 v228.47,265.56
N$133  (via drill 0.35)
  Top 0.508: v71.75,28.7 71.12,29.34 71.12,52.2 B2.10
  Bottom 0.508: A3.8 108.58,28.7 v71.75,28.7
N$134
  Bottom 0.508: B1.1 24,50.8 59.56,50.8 | B2.13 59.56,50.8 | A3.11 96.14,37.34 66.17,37.34 60.96,42.55 60.96,50.67 59.69,50.67 59.56,50.8
N$135
  Bottom 0.508: D4.3 144.15,97.28 172.09,97.28 D5.13
N$143  (via drill 0.35)
  Top 0.508: B4.11 139.7,52.2 v139.7,24.89
  Bottom 0.508: A3.2 A3.3 102.23,24.89 v139.7,24.89
N$144  (via drill 0.35)
  Top 0.508: C3.1 v92.71,47.75
  Bottom 0.508: B2.7 71.75,47.75 v92.71,47.75
N$145  (via drill 0.35)
  Top 0.508: v93.85,53.47 93.98,53.59 93.98,67.44 C3.2
  Bottom 0.508: v93.85,53.47 B2.9
N$146  (via drill 0.35)
  Top 0.508: v104.14,51.56 104.14,67.44 C3.6
  Bottom 0.508: B2.12 66.67,51.56 v104.14,51.56
N$147  (via drill 0.35)
  Top 0.508: v137.16,71.25 138.43,72.52 C4.12
  Bottom 0.508: C5.2 171.45,71.25 v137.16,71.25
N$148
  Bottom 0.508: C5.3 173.61,71.63 173.61,74.42 150.5,74.42 C4.8
N$149
  Bottom 0.508: C4.6 147.96,66.8 177.16,66.8 C5.4
N$150
  Top 0.508: B5.12 181.61,58.55 C5.5
N$151
  Top 0.508: B5.6 187.96,49.66 187.96,64.9 C5.6
N$152
  Top 0.508: C5.11 182.88,72.52 182.88,57.28 B5.8
N$153
  Top 0.508: A5.12 175.26,31.88 175.26,75.06 C5.12
N$157
  Top 0.508: J9.4 332.74,237.62 332.74,247.14 340.49,254.89 340.49,261.62 R39.1 L9.7
N$158  (via drill 0.35)
  Top 0.508: R28.1 L8.1 | v277.75,265.56 v277.75,244.22
  Bottom 0.508: J8.13 288.04,244.22 v277.75,244.22 | R28.1 v277.75,265.56
N$159  (via drill 0.35)
  Top 0.508: R30.1 L8.2 | v278.64,266.95 v278.64,243.33
  Bottom 0.508: J8.14 286.38,243.33 v278.64,243.33 | v278.64,266.95 284.35,266.95 R30.1
N$160  (via drill 0.35)
  Top 0.508: v285.75,253.11 J8.15 | v288.29,257.81 R32.1 L8.3
  Bottom 0.508: v285.75,253.11 282.45,253.11 281.05,254.51 281.05,257.81 v288.29,257.81
N$161  (via drill 0.35)
  Top 0.508: v279.53,264.16 v279.53,233.81 | R34.1 L8.4
  Bottom 0.508: v279.53,233.81 J8.1 | v279.53,264.16 289.43,264.16 R34.1
N$162  (via drill 0.35)
  Top 0.508: J8.2 284.48,235.08 v284.48,254 | R36.1 L8.5
  Bottom 0.508: v284.48,254 282.7,254 281.81,254.89 281.81,256.92 288.67,256.92 293.37,261.62 R36.1
N$163  (via drill 0.35)
  Top 0.508: v44.7,254.89 v44.7,174.75
  Bottom 0.508: G1.9 33.66,174.75 v44.7,174.75 | v44.7,254.89 44.58,254.76 33.66,254.76 K1.6
N$164
  Top 0.508: J8.4 297.18,240.16 297.18,249.68 302.39,254.89 302.39,261.62 R40.1 L8.7
N$165  (via drill 0.35)
  Top 0.508: B4.4 v140.97,33.4
  Bottom 0.508: A8.11 290.58,33.4 v140.97,33.4
N$166  (via drill 0.35)
  Top 0.508: v85.47,60.71 v85.47,267.84 | B4.8 v148.59,60.71
  Bottom 0.508: K1.12 27.69,267.84 v85.47,267.84 | v148.59,60.71 v85.47,60.71
N$167  (via drill 0.35)
  Top 0.508: v190.37,265.56 v190.37,243.46 | L5.9 185.42,285.88 185.42,266.83 R68.1
  Bottom 0.508: J5.12 181.1,243.46 v190.37,243.46 | R68.1 v190.37,265.56
N$168  (via drill 0.35)
  Top 0.508: R53.1 L7.1 | v240.54,265.56 v240.54,236.6
  Bottom 0.508: J7.4 249.94,236.6 v240.54,236.6 | R53.1 v240.54,265.56
N$169  (via drill 0.35)
  Top 0.508: R55.1 L7.2 | v241.43,264.16 v241.43,235.71
  Bottom 0.508: J7.3 248.28,235.71 v241.43,235.71 | v241.43,264.16 246.25,264.16 R55.1
N$170  (via drill 0.35)
  Top 0.508: v40.51,72.26 v40.51,170.94 | v142.24,47.75 142.24,67.44 C4.4
  Bottom 0.508: G1.10 31.11,170.94 v40.51,170.94 | v40.51,72.26 98.17,72.26 98.3,72.14 127.51,72.14 132.84,66.8 139.06,66.8 C4.4 | B5.2 172.09,47.75 v142.24,47.75
N$171  (via drill 0.35)
  Top 0.508: J7.2 246.38,235.08 v246.38,252.35 | R57.1 L7.3
  Bottom 0.508: v246.38,252.35 246.25,252.48 243.84,252.48 242.19,254.13 242.19,263.4 248.03,263.4 R57.1
N$172  (via drill 0.35)
  Top 0.508: v239.65,266.95 v239.65,233.81 | R59.1 L7.4
  Bottom 0.508: v239.65,233.81 J7.1 | v239.65,266.95 251.33,266.95 R59.1
N$173  (via drill 0.35)
  Top 0.508: v221.49,78.11 222.25,78.87 D6.7
  Bottom 0.508: C6.15 211.46,78.23 221.36,78.23 v221.49,78.11 221.62,78.23 225.3,78.23 229.87,73.66 288.16,73.66 C8.12
N$174  (via drill 0.35)
  Top 0.508: v180.34,26.67 180.34,44.58 B5.5
  Bottom 0.508: A4.6 149.73,26.67 v180.34,26.67
N$175  (via drill 0.35)
  Top 0.508: v247.65,253.11 J7.15 | R61.1 L7.5
  Bottom 0.508: v247.65,253.11 247.52,253.24 244.22,253.24 242.95,254.51 242.95,262.64 252.35,262.64 R61.1
N$176  (via drill 0.35)
  Top 0.508: v250.19,253.87 J7.14 | R63.1 L7.6
  Bottom 0.508: v250.19,253.87 250.06,254 244.6,254 243.71,254.89 243.71,261.87 254.13,261.87 R63.1
N$177  (via drill 0.35)
  Top 0.508: v165.23,56.26 v165.23,101.35 | A5.13 175.9,28.7 177.8,28.7 177.8,52.2 B5.11
  Bottom 0.508: D1.12 27.56,102.62 53.72,102.62 55.37,100.97 64.77,100.97 65.53,101.73 95.76,101.73 96.14,101.35 v165.23,101.35 | v165.23,56.26 165.35,56.13 176.4,56.13 B5.11
N$178
  Top 0.508: J7.13 264.29,252.98 264.29,261.62 R65.1 L7.7
N$179  (via drill 0.35)
  Top 0.508: R54.1 L5.1 | v162.69,265.56 v162.69,236.6
  Bottom 0.508: J5.4 173.74,236.6 v162.69,236.6 | R54.1 v162.69,265.56
N$180  (via drill 0.35)
  Top 0.508: R45.1 L6.1 | v201.68,265.56 v201.68,236.47
  Bottom 0.508: J6.4 211.96,236.47 v201.68,236.47 | R45.1 v201.68,265.56
N$181  (via drill 0.35)
  Top 0.508: L6.2 R46.1 209.68,265.43 v209.68,256.92 | J6.3 213.36,235.08 v213.36,254
  Bottom 0.508: v213.36,254 225.3,254 226.19,254.89 226.19,256.92 v209.68,256.92
N$182  (via drill 0.35)
  Top 0.508: v202.56,264.16 v202.56,235.58 | R47.1 L6.3
  Bottom 0.508: J6.2 207.65,235.71 202.69,235.71 v202.56,235.58 | v202.56,264.16 210.69,264.16 R47.1
N$183  (via drill 0.35)
  Top 0.508: v203.33,233.81 203.45,233.93 203.45,266.83 v203.33,266.95 | R48.1 L6.4
  Bottom 0.508: v203.33,233.81 J6.1 | v203.33,266.95 213.23,266.95 R48.1
N$184  (via drill 0.35)
  Top 0.508: v209.55,253.11 J6.15 | R49.1 L6.5
  Bottom 0.508: v209.55,253.11 209.42,253.24 206.12,253.24 204.85,254.51 204.85,263.4 215.01,263.4 R49.1
N$185  (via drill 0.35)
  Top 0.508: v212.09,253.87 J6.14 | R50.1 L6.6
  Bottom 0.508: v212.09,253.87 211.96,254 206.5,254 205.61,254.89 205.61,262.64 216.79,262.64 R50.1
N$186
  Top 0.508: J6.13 226.19,252.98 226.19,261.62 R51.1 L6.7
N$187  (via drill 0.35)
  Top 0.508: R56.1 L5.2 | v163.58,264.16 v163.58,235.71
  Bottom 0.508: J5.3 172.09,235.71 v163.58,235.71 | v163.58,264.16 170.05,264.16 R56.1
N$188  (via drill 0.35)
  Top 0.508: J5.2 170.18,235.08 v170.18,253.11 | v173.99,257.81 R58.1 L5.3
  Bottom 0.508: v170.18,253.11 170.05,253.24 168.02,253.24 166.75,254.51 166.75,257.81 v173.99,257.81
N$189  (via drill 0.35)
  Top 0.508: v164.47,263.27 v164.47,233.81 | R60.1 L5.4
  Bottom 0.508: v164.47,233.81 J5.1 | v164.47,263.27 164.59,263.4 174.37,263.4 R60.1
N$190  (via drill 0.35)
  Top 0.508: v171.45,253.87 J5.15 | R62.1 L5.5
  Bottom 0.508: v171.45,253.87 171.32,254 168.4,254 167.51,254.89 167.51,256.92 174.37,256.92 179.07,261.62 R62.1
N$191  (via drill 0.35)
  Top 0.508: v173.99,253.87 J5.14 | v181.61,256.92 R64.1 L5.6
  Bottom 0.508: v173.99,253.87 174.12,254 187.2,254 188.09,254.89 188.09,256.92 v181.61,256.92
N$192
  Top 0.508: J5.13 188.09,252.98 188.09,261.62 R66.1 L5.7
N$194
  Bottom 0.508: F8.4 289.18,141.48 261.24,141.48 F7.10
N$195
  Bottom 0.508: F7.4 258.19,140.21 285.37,140.21 F8.2
N$197  (via drill 0.35)
  Top 0.508: v224.79,135.25 E6.9
  Bottom 0.508: v224.79,135.25 224.92,135.38 225.3,135.38 226.06,136.14 226.06,143 | 226.06,143 226.06,144.91 F6.9 | F7.11 253.37,143 226.06,143
N$198  (via drill 0.35)
  Top 0.508: F7.13 v250.19,147.7 | v203.33,146.81 v203.33,170.05
  Bottom 0.508: 211.33,146.69 212.34,147.7 v250.19,147.7 | 211.33,146.69 F6.15 | G5.13 176.78,170.05 v203.33,170.05 | v203.33,146.81 211.2,146.81 211.33,146.69
N$199  (via drill 0.35)
  Top 0.508: E6.15 212.6,125.09 212.6,126.37 222.25,136.02 F6.7 223.52,138.56 v223.52,146.81
  Bottom 0.508: F7.12 250.82,146.81 v223.52,146.81
N$200  (via drill 0.35)
  Top 0.508: v197.36,159.89 v197.36,123.95
  Bottom 0.508: E6.12 215.26,123.95 v197.36,123.95 | v197.36,159.89 176.78,159.89 G5.1
N$201  (via drill 0.35)
  Top 0.508: v193.68,160.78 v193.68,124.84
  Bottom 0.508: E6.11 216.92,124.84 v193.68,124.84 | v193.68,160.78 178.44,160.78 G5.2
N$202  (via drill 0.35)
  Top 0.508: v273.18,91.57 v273.18,176.4
  Bottom 0.508: G5.12 178.44,170.94 220.22,170.94 220.98,171.7 220.98,176.4 v273.18,176.4 | D8.1 v273.18,91.57
N$206
  Top 0.508: H6.9 223.52,193.17 223.52,174.12 G6.9
  Bottom 0.508: G5.6 188.09,169.16 221.11,169.16 G6.9
N$207  (via drill 0.35)
  Top 0.508: v208.28,162.43 208.28,171.58 G6.15 209.68,172.97 v209.68,184.78
  Bottom 0.508: G5.3 179.2,162.56 208.15,162.56 v208.28,162.43 | H6.7 220.22,184.78 v209.68,184.78
N$208  (via drill 0.35)
  Top 0.508: v185.42,119.25 185.42,148.21 179.07,154.56 G5.4 177.8,166.5 177.8,185.55 H5.4 179.2,186.94 v179.2,191.64
  Bottom 0.508: E7.12 249.94,119.25 v185.42,119.25 | H6.15 206.76,191.64 v179.2,191.64
N$210  (via drill 0.35)
  Top 0.508: H5.1 v171.45,176.4
  Bottom 0.508: G6.12 213.61,176.4 v171.45,176.4
N$211
  Bottom 0.508: A2.5 62.36,27.94 29.34,27.94 A1.11
N$212  (via drill 0.35)
  Top 0.508: v219.71,183.01 G6.11
  Bottom 0.508: v219.71,183.01 219.58,183.13 177.67,183.13 H5.2
N$214  (via drill 0.35)
  Top 0.508: G5.5 182.12,165.73 182.12,170.94 182.88,171.7 182.88,185.55 H5.5 | v231.14,163.32 v231.14,112.52
  Bottom 0.508: E7.3 250.82,112.52 v231.14,112.52 | v231.14,163.32 183.51,163.32 G5.5
N$215
  Bottom 0.508: E8.2 290.19,112.52 296.55,112.52 E8.6
N$216  (via drill 0.35)
  Top 0.508: v330.2,118.75 330.2,143.64 F9.11
  Bottom 0.508: E8.4 297.56,118.62 330.07,118.62 v330.2,118.75
N$217  (via drill 0.35)
  Top 0.508: v317.63,143 v317.63,116.33
  Bottom 0.508: E8.5 297.81,116.33 v317.63,116.33 | v317.63,143 337.19,143 F9.8
N$219  (via drill 0.35)
  Top 0.508: v260.35,156.21 G7.6 | v297.18,153.8 297.18,123.32 E8.9
  Bottom 0.508: v260.35,156.21 262,154.56 288.29,154.56 289.05,153.8 v297.18,153.8
N$220
  Bottom 0.508: E8.1 290.7,119.38 298.32,119.38 E8.8
N$223
  Top 0.508: G7.3 254.51,163.45 254.51,151.51 256.54,149.48 256.54,125.86 E7.9
N$225
  Bottom 0.508: G7.11 257.94,175.51 295.78,175.51 G8.9
N$226  (via drill 0.35)
  Top 0.508: v251.46,133.1 251.46,153.29 252.73,154.56 252.73,160.27 248.92,164.08 248.92,171.58 G7.13
  Bottom 0.508: F9.6 332.36,133.1 v251.46,133.1
N$227  (via drill 0.35)
  Top 0.508: v191.26,88.01 v191.26,192.53
  Bottom 0.508: H4.10 145.41,192.53 v191.26,192.53 | v191.26,88.01 215.39,88.01 215.52,88.14 275.34,88.14 275.46,88.01 289.81,88.01 D8.4
N$228  (via drill 0.35)
  Top 0.508: G5.8 185.42,171.58 v185.42,156.34 | v235.97,94.36 v235.97,156.34
  Bottom 0.508: v235.97,156.34 v185.42,156.34 | v235.97,94.36 293.12,94.36 D8.5
N$229
  Top 0.508: E8.12 297.18,115.7 297.18,92.84 D8.6
N$231
  Bottom 0.508: I6.5 221.62,212.85 255.91,212.85 I7.5
N$232
  Bottom 0.508: I6.12 216.53,216.66 258.44,216.66 I7.9
N$233
  Bottom 0.508: I5.3 178.44,209.04 215.26,209.04 I6.4
N$234
  Bottom 0.508: I5.6 188.09,214.88 208.41,214.88 I6.13
N$235
  Bottom 0.508: G7.8 264.8,170.94 288.93,170.94 G8.12
OCEAN
  Top 0.508: F5.3 176.4,137.16 176.4,122.17 E5.12
  Bottom 0.508: E4.12 141.1,124.71 174.88,124.71 176.53,123.06 E5.12
OCEANCOLLISION
  Top 0.508: E9.8 337.82,120.78 337.82,80.14 C9.10
  Bottom 0.508: C7.2 253.37,71.88 329.56,71.88 C9.10
OCEANVEN  (via drill 0.35)
  Top 0.508: v154.94,137.29 v154.94,170.94 155.07,171.07 v155.07,179.96 | v271.02,162.43 v271.02,32.51 | v254,179.96 254,166.5 G7.4
  Bottom 0.508: v154.94,137.29 F5.1 | v154.94,170.94 112.39,170.94 G3.8 | A7.10 259.71,32.51 v271.02,32.51 | v271.02,162.43 258.06,162.43 G7.4 | v254,179.96 v155.07,179.96
OFLOOR
  Top 0.508: C9.13 328.3,74.42 332.74,74.42 332.74,110.62 E9.6
ONES
  Bottom 0.508: A1.4 28.57,21.08 67.82,21.08 68.58,21.84 68.58,28.7 70.48,28.7 A2.8
P  (via drill 0.35)
  Top 0.508: B8.1 288.29,48.39 B8.13 | B8.4 B8.11 293.24,53.59 293.24,58.67 R75.1 | A6.7 A6.10 220.98,31.88 220.98,52.2 B6.10 C6.7 | C6.6 219.71,64.9 R71.1 213.36,58.55 213.36,47.12 B6.3 | 254,89.66 254,96.9 252.73,98.17 D7.12 | 254,89.66 R70.1 | D7.6 258.44,89.66 254,89.66 | D6.10 E6.7 223.52,115.7 v223.52,135.38 | E7.1 250.19,116.97 E7.13 | E7.11 E7.4 D7.11 | C1.1 20.95,66.8 22.86,66.8 22.86,71.37 21.59,72.64 C1.13 22.1,76.84 22.1,78.36 22.86,79.12 22.86,111.63 22.99,111.76 | 22.99,111.76 21.59,113.16 E1.2 | 22.99,111.76 R79.1 | E3.2 97.79,110.62 R77.1 104.14,109.35 104.14,120.78 E3.10 | 208.15,92.71 208.28,92.84 208.28,101.09 | 208.15,92.71 D6.1 | 208.28,101.09 208.28,113.16 E6.1 | v171.45,65.91 C5.1 | C6.1 208.28,69.98 208.28,92.58 208.15,92.71 | v115.06,66.17 v115.06,106.81 | v208.41,101.09 208.28,101.09 | I1.1 24.13,216.03 I1.12 | I2.1 59.69,213.49 I2.13 | K2.1 59.69,259.21 K2.13 | R78.1 64.64,270.76 64.64,264.41 K2.11 K2.4 64.26,256.16 64.26,243.33 63.5,242.57 63.5,240.03 68.58,234.95 68.58,227.46 R72.1 I2.10 | H3.11 H3.4 | v105.41,206.76 H3.10 | R76.1 v93.98,207.01 | G8.4 G8.11 293.24,172.97 v293.24,183.39 | I7.10 257.81,213.49 I7.4 254,209.68 254,188.09 H7.3 | H5.9 183.64,194.94 183.64,198.75 R73.1 | 219.71,191.9 H6.10 | 219.71,191.9 H6.6 220.98,185.55 220.98,166.5 G6.6 | R74.1 218.44,202.06 218.44,193.17 219.71,191.9 | F6.10 215.39,151.76 215.39,164.47 G6.4
  Bottom 0.508: B8.11 B8.10 297.69,55.25 | B8.8 299.08,55.37 297.81,55.37 297.69,55.25 | B8.13 290.19,55.37 297.56,55.37 297.69,55.25 | A6.1 208.91,21.08 215.26,21.08 A6.5 A6.6 A6.7 | B6.1 208.91,47.75 210.19,47.75 B6.3 | C6.6 C6.7 | R75.1 290.83,61.09 R71.1 211.07,65.91 204.47,65.91 204.34,66.04 | D7.11 D7.12 | E7.8 260.99,123.95 257.18,123.95 257.05,123.83 | E7.11 257.05,123.83 | E7.13 252.09,123.95 256.92,123.95 257.05,123.83 | E6.7 224.16,116.33 245.75,116.33 E7.1 | 204.34,66.04 171.58,66.04 v171.45,65.91 171.32,66.04 115.06,66.04 | C6.1 204.34,66.04 | 115.06,66.04 105.54,66.04 C3.5 100.97,70.61 99.69,70.61 C3.3 95.89,66.8 20.95,66.8 C1.1 | v115.06,106.81 R77.1 | v115.06,66.17 115.06,66.04 | D6.10 220.34,101.09 v208.41,101.09 | I1.12 I1.11 28.57,220.47 57.78,220.47 57.91,220.34 | I2.4 62.87,209.04 59.05,209.04 I2.1 | I2.13 57.91,220.34 | K2.8 70.48,266.19 66.67,266.19 66.55,266.06 | K2.11 66.55,266.06 | K2.13 61.59,266.19 66.42,266.19 66.55,266.06 | H3.1 97.16,189.36 100.97,189.36 H3.4 | H3.11 H3.10 107.31,196.98 108.58,196.98 H3.8 | R76.1 91.44,226.19 R72.1 | v93.98,207.01 105.16,207.01 v105.41,206.76 106.17,205.99 178.94,205.99 179.07,205.87 | I2.10 65.41,220.47 58.04,220.47 57.91,220.34 | G8.1 287.65,167.13 291.46,167.13 G8.4 | G8.8 299.08,170.94 295.27,170.94 G8.11 | v293.24,183.39 256.16,183.39 H7.3 H7.2 H7.1 245.75,188.72 218.06,188.72 217.93,188.59 | F6.10 220.34,143 212.72,143 F6.1 208.91,135.38 v223.52,135.38 | G6.7 G6.6 217.81,167.13 212.98,167.13 212.85,167 | G6.1 208.91,167.13 212.72,167.13 212.85,167 | G6.4 212.85,167 | H6.1 208.91,188.72 217.81,188.72 217.93,188.59 | H6.6 217.93,188.59
  Bottom 0.508: 179.07,205.87 R73.1 | 179.07,205.87 214.63,205.87 R74.1
P1LED  (via drill 0.35)
  Top 0.508: v41.91,126.62 R6.2 | v355.22,151.76 v355.22,126.62 | v360.93,153.42 P1.N
  Bottom 0.508: v355.22,126.62 v41.91,126.62 | v355.22,151.76 360.93,151.76 P1.N v360.93,153.42
Q  (via drill 0.35)
  Top 0.508: v30.48,100.97 30.48,120.78 E1.10 | v99.06,142.37 99.06,123.32 E3.13
  Bottom 0.508: D1.8 32.38,101.09 30.61,101.09 v30.48,100.97 | E3.13 95.89,120.14 31.11,120.14 E1.10 | F5.9 182.25,146.81 152.91,146.81 148.08,141.99 106.17,141.99 105.79,142.37 v99.06,142.37
RED  (via drill 0.35)
  Top 0.508: v163.45,158.75 v163.45,122.05 | v360.93,149.48 P1.P
  Bottom 0.508: v163.45,122.05 E4.8 | v163.45,158.75 163.58,158.62 347.09,158.62 356.36,149.35 | 356.36,149.35 357.76,147.95 360.93,147.95 P1.P | v360.93,149.48 356.49,149.48 356.36,149.35
SA  (via drill 0.35)
  Top 0.508: v240.54,70.61 v240.54,137.29 239.65,138.18 v239.65,208.15 | v328.93,65.91 C9.3 | F7.9 v260.35,141.1 260.48,140.97 v260.48,139.32
  Bottom 0.508: I5.2 176.66,208.28 239.65,208.28 | 239.65,208.28 247.52,208.28 I7.2 | C6.3 214,70.61 v240.54,70.61 245.11,66.04 328.8,66.04 v328.93,65.91 | v240.54,137.29 F7.1 251.33,140.97 260.22,140.97 v260.35,141.1 | F8.1 283.72,139.32 v260.48,139.32 | v239.65,208.15 239.65,208.28
SB  (via drill 0.35)
  Top 0.508: I5.5 182.88,212.22 v182.88,222.12 | F7.2 250.57,136.91 250.57,124.08 251.46,123.19 251.46,80.01 254,77.47 v254,64.26 | v236.98,135.38 v236.98,221.87
  Bottom 0.508: v182.88,222.12 183.01,222 236.98,222 | 236.98,222 249.3,222 I7.12 | 251.97,135.51 252.09,135.38 255.91,135.38 256.03,135.51 | 251.97,135.51 F7.2 | F7.5 256.03,135.51 | F8.3 288.93,135.38 256.16,135.38 256.03,135.51 | C6.4 219.2,64.14 254,64.14 | 254,64.14 331.98,64.14 C9.6 | v254,64.26 254,64.14 | v236.98,135.38 251.84,135.38 251.97,135.51 | v236.98,221.87 236.98,222
SCORE  (via drill 0.35)
  Top 0.508: E4.5 144.78,113.16 v144.78,78.87
  Bottom 0.508: v144.78,78.87 145.41,78.23 184.78,78.23 C5.8
SCOREA  (via drill 0.35)
  Top 0.508: v147.32,80.01 v147.32,48.64
  Bottom 0.508: B5.3 173.74,48.64 v147.32,48.64 | v147.32,80.01 104.01,80.01 C3.13
SCOREB  (via drill 0.35)
  Top 0.508: C4.3 142.24,72.52 v142.24,79.12
  Bottom 0.508: v142.24,79.12 142.11,78.99 105.54,78.99 C3.12
SCOREC  (via drill 0.35)
  Top 0.508: B5.1 171.96,46.36 171.96,51.56 172.72,52.32 v172.72,72.39
  Bottom 0.508: v172.72,72.39 130.81,72.39 129.54,73.66 108.08,73.66 C3.11
SCORED  (via drill 0.35)
  Top 0.508: A5.1 164.34,30.1 v164.34,73.28
  Bottom 0.508: v164.34,73.28 131.06,73.28 129.92,74.42 109.86,74.42 C3.10
SCOREE
  Bottom 0.508: C3.9 112.39,78.23 144.15,78.23 C4.9
SCOREEN  (via drill 0.35)
  Top 0.508: C3.4 101.6,69.98 v101.6,87.88 | v185.42,87.88 185.42,113.16 E5.6
  Bottom 0.508: v185.42,87.88 v101.6,87.88
SCOREF
  Bottom 0.508: C4.1 129.16,72.9 98.68,72.9 C3.15
SCOREG  (via drill 0.35)
  Top 0.508: v99.06,58.04 99.06,75.06 C3.14
  Bottom 0.508: B5.9 179.58,58.04 v99.06,58.04
SCOREVEN
  Top 0.508: B1.8 30.48,49.66 30.48,24.26 A1.5
  Bottom 0.508: A1.2 23.5,24.89 27.3,24.89 A1.5
SOUND  (via drill 0.35)
  Top 0.508: v346.33,124.08 v346.33,213.23 | v360.93,125.73 P1.W
  Bottom 0.508: v346.33,213.23 331.6,213.23 330.2,214.63 VR1.2 | v346.33,124.08 P1.W v360.93,125.73
SQA  (via drill 0.35)
  Top 0.508: C6.14 213.36,77.6 213.36,125.86 v215.01,127.51 | F8.5 v295.91,127.51
  Bottom 0.508: v295.91,127.51 v215.01,127.51
SQB  (via drill 0.35)
  Top 0.508: v214.63,81.41 C6.13 | v299.72,81.41 299.72,143.64 F8.9 | v277.62,148.59 v277.62,192.53
  Bottom 0.508: v299.72,81.41 v214.63,81.41 | H7.11 257.18,192.53 v277.62,192.53 | v277.62,148.59 277.75,148.46 294.89,148.46 F8.9
SQC  (via drill 0.35)
  Top 0.508: C6.12 218.44,77.6 v218.44,130.18 | v292.1,130.18 292.1,143.64 F8.11
  Bottom 0.508: v292.1,130.18 v218.44,130.18
SQD  (via drill 0.35)
  Top 0.508: v274.95,72.77 v274.95,146.81 v274.95,191.64
  Bottom 0.508: C6.11 223.27,72.77 v274.95,72.77 | v274.95,146.81 286.38,146.81 F8.13 | H7.12 255.52,191.64 v274.95,191.64
START  (via drill 0.35)
  Top 0.508: v115.95,48.77 v115.95,120.14
  Bottom 0.508: B3.2 B3.3 103.12,48.64 115.95,48.64 | B4.12 133.6,48.64 115.95,48.64 | E3.9 109.86,120.14 v115.95,120.14 | v115.95,48.77 115.95,48.64
STARTLINE  (via drill 0.35)
  Top 0.508: v315.85,28.7 v315.85,146.81 315.72,146.94 v315.72,181.48
  Bottom 0.508: A8.10 297.81,28.7 v315.85,28.7 | v315.85,146.81 324.49,146.81 F9.13 | H4.6 151.38,181.48 v315.72,181.48
STOPDOWN
  Top 0.508: D9.2 328.8,89.15 328.8,78.99 C9.11
STOPUP  (via drill 0.35)
  Top 0.508: C9.8 v339.09,89.54
  Bottom 0.508: D9.5 336.04,89.54 v339.09,89.54
SUBDOWN  (via drill 0.35)
  Top 0.508: J5.5 v179.07,221.23
  Bottom 0.508: I6.10 217.04,221.23 v179.07,221.23
SUBEN
  Top 0.508: C7.1 252.73,73.79 C7.12
  Bottom 0.508: C7.8 260.99,74.42 254.63,74.42 C7.12
SUBHEN  (via drill 0.35)
  Top 0.508: v289.56,78.23 289.56,97.92 289.69,98.04 | D8.12 289.69,98.04 | v289.69,134.87 289.56,134.75 289.56,98.17 289.69,98.04
  Bottom 0.508: C7.9 262.25,78.23 v289.56,78.23 | F9.4 329.06,134.87 v289.69,134.87
SUBLEVEL
  Top 0.508: I6.2 215.9,214.76 215.9,232.54 J6.5
SUBMARINE  (via drill 0.35)
  Top 0.508: E5.10 v181.61,116.46 | v192.15,112.52 v192.15,78.99
  Bottom 0.508: E4.2 137.79,112.52 179.58,112.52 179.71,112.65 | 179.71,112.65 180.34,113.28 180.34,116.46 v181.61,116.46 | C7.11 252.6,78.99 v192.15,78.99 | v192.15,112.52 179.83,112.52 179.71,112.65
SUBPROMDATA  (via drill 0.35)
  Top 0.508: v237.87,78.11 v237.87,218.57
  Bottom 0.508: v237.87,218.57 I6.8 | v237.87,78.11 238,78.23 248.28,78.23 C7.13
SUBUP  (via drill 0.35)
  Top 0.508: I6.1 210.82,212.22 v210.82,230.12
  Bottom 0.508: v210.82,230.12 251.59,230.12 J7.5
SUBVEN  (via drill 0.35)
  Top 0.508: v215.9,87.25 v215.9,97.28 | v256.92,87.25 257.81,86.36 257.81,85.34 | C7.10 257.81,85.34 | v288.29,85.34 C8.13 | v257.94,85.34 257.81,85.34 | v269.24,85.47 v269.24,188.72
  Bottom 0.508: D6.15 211.46,97.28 v215.9,97.28 | v256.92,87.25 v215.9,87.25 | v257.94,85.34 269.24,85.34 | 269.24,85.34 v288.29,85.34 | H7.6 262.25,188.72 v269.24,188.72 | v269.24,85.47 269.24,85.34
SYNC  (via drill 0.35)
  Top 0.508: v107.95,157.99 G3.6 | v344.55,136.02 v344.55,157.23 | v360.93,134.37 P1.T
  Bottom 0.508: v107.95,157.99 108.08,157.86 170.69,157.86 172.34,156.21 174.62,156.21 174.75,156.34 177.67,156.34 177.8,156.21 179.71,156.21 180.72,157.23 v344.55,157.23 | v344.55,136.02 360.93,136.02 P1.T v360.93,134.37
TA  (via drill 0.35)
  Top 0.508: v232.03,209.17 v232.03,111.63
  Bottom 0.508: E6.3 214.88,111.63 v232.03,111.63 | v232.03,209.17 231.9,209.04 224.16,209.04 I6.6
TB  (via drill 0.35)
  Top 0.508: v198.88,220.34 v198.88,116.33
  Bottom 0.508: E6.4 212.72,116.33 v198.88,116.33 | v198.88,220.34 199.01,220.47 215.26,220.47 I6.11
TENS
  Bottom 0.508: A1.1 21.72,20.32 68.2,20.32 69.85,21.97 A2.6
THA  (via drill 0.35)
  Top 0.508: v293.37,128.4 E8.11 | v213.36,128.4 213.36,153.29 214.63,154.56 214.63,162.69 G6.3
  Bottom 0.508: v213.36,128.4 v293.37,128.4
TORPEDO  (via drill 0.35)
  Top 0.508: E4.4 135.89,119.51 E4.13 | v266.57,28.7 266.45,28.83 266.45,152.02 | 266.45,152.02 266.45,163.19 v266.57,163.32 | v266.57,152.02 266.45,152.02 | H5.8 185.42,193.17 185.42,176.53 188.09,173.86 v188.09,167.89 | v173.99,128.27 E5.13 | v192.15,167.77 v192.15,128.27
  Bottom 0.508: E5.13 168.28,116.33 142.88,116.33 E4.4 | A7.12 254.63,28.7 v266.57,28.7 | v266.57,163.32 259.71,163.32 G7.5 255.14,167.89 192.15,167.89 | F9.10 326.9,152.02 v266.57,152.02 | 192.15,167.89 v188.09,167.89 | v192.15,128.27 v173.99,128.27 | v192.15,167.77 192.15,167.89
TORPEDOHCORRECT  (via drill 0.35)
  Top 0.508: G7.9 v260.35,167.89 | v304.67,163.32 v304.67,139.19
  Bottom 0.508: v260.35,167.89 293.24,167.89 G8.5 297.81,163.32 v304.67,163.32 | F9.2 324.49,139.19 v304.67,139.19
TORPEDOHEN  (via drill 0.35)
  Top 0.508: v252.73,183.9 G7.12 | H5.12 178.44,196.34 182.88,196.34 182.88,188.09 H5.6 | F9.12 329.69,145.67 v329.69,167.64
  Bottom 0.508: v252.73,183.9 187.07,183.9 H5.6 | v329.69,167.64 327.15,170.18 255.4,170.18 G7.12
TORPEDOVCORRECT  (via drill 0.35)
  Top 0.508: 287.02,132.21 287.02,150.75 290.83,154.56 G8.3 | 287.02,132.21 v287.02,118.11 | v323.85,132.21 F9.1 | v287.15,132.21 287.02,132.21
  Bottom 0.508: E6.6 223.39,118.11 v287.02,118.11 | v287.15,132.21 v323.85,132.21
TORPEDOVEN  (via drill 0.35)
  Top 0.508: v256.54,196.34 256.54,188.09 H7.5 | v279.4,196.34 v279.4,93.47
  Bottom 0.508: H5.13 175.9,196.34 v256.54,196.34 v279.4,196.34 | D8.2 286.38,93.47 v279.4,93.47
TORPEDOVINCORRECT  (via drill 0.35)
  Top 0.508: G8.2 287.02,166.5 v287.02,184.28
  Bottom 0.508: v287.02,184.28 286.38,184.91 257.18,184.91 H7.4
UP
  Top 0.508: F7.3 254,138.56 254,150.88 253.49,151.38 253.49,162.05 251.46,164.08 251.46,224.92 J7.7
VBLANK
  Bottom 0.508: G1.3 G1.4 28.57,167.13 60.33,167.13 G2.3
VCC  (via drill 0.35, 0.75)
  Top 0.508: VR2.1 S1.3 | R44.2 320.04,83.95 | 320.04,83.95 R43.1 | 16.51,106.81 R79.2 | R71.2 204.47,61.09 | 52.07,271.91 R78.2 | 90.17,106.81 R77.2 | 52.07,111.89 Q2.E | R76.2 104.14,212.09 105.03,211.2 I3.5 | 242.57,83.95 R70.2 | 280.67,59.82 R75.2 | 166.37,204.6 R73.2 | 204.47,204.6 R74.2 | 57.15,228.09 R72.2 | 52.07,105.54 CC3.1 | 52.07,82.68 R7.2 | 166.37,129.67 R9.2 | 280.67,83.95 R69.2 | 318.77,83.95 320.04,83.95 | v319.15,176.66 318.77,176.66
  Top 1.016: 16.51,264.29 16.51,228.09 | 16.51,228.09 16.51,218.57 | 16.51,218.57 16.51,183.01 | 16.51,183.01 16.51,172.85 | 16.51,172.85 16.51,155.07 | 16.51,155.07 16.51,144.91 | 16.51,144.91 16.51,122.05 | 16.51,122.05 16.51,106.81 16.51,99.19 | 16.51,99.19 16.51,76.33 | 16.51,76.33 16.51,53.47 | 16.51,53.47 16.51,30.61 A1.14 | K1.14 16.51,264.29 | 16.51,53.47 B1.14 | C1.14 16.51,76.33 | D1.14 16.51,99.19 | E1.14 16.51,122.05 | F1.14 16.51,144.91 | G1.14 16.51,172.85 | H1.5 29.21,185.55 26.67,183.01 16.51,183.01 | 16.51,218.57 I1.14 | 16.51,228.09 26.67,228.09 29.21,230.63 J1.5 | 52.07,287.15 52.07,271.91 52.07,264.29 | 52.07,264.29 52.07,228.09 | 52.07,228.09 52.07,218.57 | 52.07,218.57 52.07,182.37 | 52.07,182.37 52.07,172.85 | 52.07,172.85 52.07,155.07 | 52.07,155.07 52.07,144.91 | 52.07,144.91 52.07,111.89 52.07,105.54 52.07,82.68 52.07,53.47 | 52.07,53.47 52.07,30.61 A2.14 | L2.14 52.07,287.15 | B2.16 52.07,53.47 | F2.14 52.07,144.91 | G2.14 52.07,172.85 | H2.5 67.31,185.55 64.14,182.37 52.07,182.37 | J2.5 67.31,230.63 64.77,228.09 57.15,228.09 52.07,228.09 | L3.16 90.17,287.15 | 90.17,287.15 90.17,255.4 | 90.17,255.4 90.17,241.43 | 90.17,241.43 90.17,205.87 | 90.17,205.87 90.17,195.07 | 90.17,195.07 90.17,172.85 | 90.17,172.85 90.17,155.07 | 90.17,155.07 90.17,144.91 | 90.17,144.91 90.17,122.05 | 90.17,122.05 90.17,106.81 90.17,99.19 | 90.17,99.19 90.17,76.33 | 90.17,76.33 90.17,40.77 | 90.17,40.77 90.17,17.91 102.87,17.91 105.41,20.45 A3.5 | B3.5 105.41,43.31 102.87,40.77 90.17,40.77 | 90.17,76.33 C3.16 | 90.17,99.19 D3.8 | 90.17,122.05 E3.14 | 90.17,144.91 F3.14 | 90.17,172.85 G3.14 | 90.17,195.07 H3.14 | 90.17,205.87 102.87,205.87 105.41,208.41 I3.5
  Top 1.016: 90.17,241.43 J3.16 | 90.17,255.4 R12.2 | L4.16 128.27,287.15 | 128.27,287.15 128.27,255.4 | 128.27,255.4 128.27,241.43 | 128.27,241.43 128.27,205.87 | 128.27,205.87 128.27,194.44 | 128.27,194.44 128.27,172.85 | 128.27,172.85 128.27,155.07 | 128.27,155.07 128.27,144.91 | 128.27,144.91 128.27,122.05 | 128.27,122.05 128.27,99.19 | 128.27,99.19 128.27,76.33 | 128.27,76.33 128.27,53.47 | 128.27,53.47 128.27,30.61 A4.14 | B4.14 128.27,53.47 | 128.27,76.33 C4.14 | 128.27,99.19 D4.14 | 128.27,122.05 E4.14 | 128.27,144.91 F4.14 | 128.27,172.85 G4.14 | 128.27,194.44 H4.14 | 128.27,205.87 140.97,205.87 143.51,208.41 I4.5 | 128.27,241.43 J4.16 | L5.16 166.37,287.15 | 166.37,287.15 166.37,255.4 | 166.37,255.4 166.37,241.43 | 166.37,241.43 166.37,218.57 | 166.37,218.57 166.37,204.6 166.37,194.44 | 166.37,194.44 166.37,172.85 | 166.37,172.85 166.37,155.07 | 166.37,155.07 166.37,144.91 | 166.37,144.91 166.37,129.67 166.37,122.05 | 166.37,122.05 166.37,99.19 | 166.37,99.19 166.37,76.33 | 166.37,76.33 166.37,53.47 | 166.37,53.47 166.37,30.61 A5.14 | B5.14 166.37,53.47 | C5.14 166.37,76.33 | D5.14 166.37,99.19 | 166.37,122.05 E5.14 | F5.14 166.37,144.91 | G5.14 166.37,172.85 | H5.14 166.37,194.44 | I5.14 166.37,218.57 | J5.16 166.37,241.43 | L6.16 204.47,287.15 | 204.47,287.15 204.47,255.4 | 204.47,255.4 204.47,241.43 | 204.47,241.43 204.47,218.57 | 204.47,218.57 204.47,204.6 204.47,194.44 | 204.47,194.44 204.47,172.85 | 204.47,172.85 204.47,155.07 | 204.47,155.07 204.47,144.91 | 204.47,144.91 204.47,122.05 | 204.47,122.05 204.47,99.19 | 204.47,99.19 204.47,76.33 | 204.47,76.33 204.47,61.09 204.47,53.47 | 204.47,53.47 204.47,30.61 A6.16 | 204.47,53.47 B6.16 | C6.16 204.47,76.33
  Top 1.016: 204.47,99.19 D6.16 | 204.47,122.05 E6.16 | F6.16 204.47,144.91 | 204.47,172.85 G6.16 | 204.47,194.44 H6.16 | 204.47,218.57 I6.14 | 204.47,241.43 J6.16 | L7.16 242.57,287.15 | 242.57,287.15 242.57,255.4 | 242.57,255.4 242.57,241.43 | 242.57,241.43 242.57,218.57 | 242.57,218.57 242.57,194.44 | 242.57,194.44 242.57,172.85 | 242.57,172.85 242.57,155.07 | 242.57,155.07 242.57,144.91 | 242.57,144.91 242.57,122.05 | 242.57,122.05 242.57,99.19 | 242.57,99.19 242.57,83.95 242.57,76.33 | 242.57,76.33 242.57,53.47 | 242.57,53.47 242.57,30.61 A7.14 | B7.14 242.57,53.47 | C7.14 242.57,76.33 | D7.14 242.57,99.19 | E7.14 242.57,122.05 | F7.14 242.57,144.91 | G7.14 242.57,172.85 | H7.14 242.57,194.44 | I7.14 242.57,218.57 | J7.16 242.57,241.43 | L8.16 280.67,287.15 | 280.67,287.15 280.67,255.4 | 280.67,255.4 280.67,241.43 | 280.67,241.43 280.67,172.85 | 280.67,172.85 280.67,155.07 | 280.67,155.07 280.67,144.91 | 280.67,144.91 280.67,122.05 | 280.67,122.05 280.67,99.19 | 280.67,99.19 280.67,83.95 280.67,76.33 | 280.67,76.33 280.67,59.82 280.67,53.47 | 280.67,53.47 280.67,30.61 A8.14 | B8.14 280.67,53.47 | C8.14 280.67,76.33 | D8.14 280.67,99.19 | E8.14 280.67,122.05 | F8.14 280.67,144.91 | G8.14 280.67,172.85 | J8.16 280.67,241.43 | L9.16 318.77,287.15 | 318.77,287.15 318.77,255.4 | 318.77,255.4 318.77,241.43 | 318.77,241.43 318.77,176.66 318.77,155.07 | 318.77,155.07 318.77,144.91 | 318.77,144.91 318.77,122.05 | 318.77,122.05 318.77,99.19 | 318.77,99.19 318.77,83.95 318.77,76.33 | 318.77,76.33 318.77,40.13 | 318.77,40.13 318.77,17.27 331.47,17.27 334.01,19.81 A9.5 | 318.77,40.13 331.47,40.13 334.01,42.67 B9.5 | C9.14 318.77,76.33 | 318.77,99.19 D9.14 | 318.77,122.05 E9.14
  Top 1.016: 318.77,144.91 F9.14 | 318.77,241.43 J9.16 | 52.07,264.29 K2.14 | 52.07,218.57 I2.14 | 318.77,255.4 R27.2 | 280.67,255.4 R28.2 | 204.47,255.4 R45.2 | 128.27,255.4 R11.2 | 16.51,155.07 CC7.1 | 52.07,155.07 CC8.1 | 90.17,155.07 CC9.1 | 128.27,155.07 CC10.1 | 166.37,155.07 CC11.1 | 204.47,155.07 CC12.1 | 242.57,155.07 CC13.1 | 280.67,155.07 CC14.1 | 318.77,155.07 CC15.1 | 318.77,287.15 v318.77,298.83 318.77,299.09 | 16.51,264.29 v16.51,298.83 16.51,299.09 | 52.07,287.15 v52.07,298.83 52.07,299.09 | 90.17,287.15 v90.17,298.83 90.17,299.09 | 128.27,287.15 v128.27,298.83 128.27,299.09 | 166.37,287.15 v166.37,298.83 166.37,299.09 | 204.47,287.15 v204.47,298.83 204.47,299.09 | 242.57,287.15 v242.57,298.83 242.57,299.09 | 280.67,287.15 v280.67,298.83 280.67,299.09 | 242.57,255.4 R53.2 | 166.37,255.4 R54.2
  Top 2.54: P1.C v360.93,185.55 P1.D
  Bottom 0.508: C1.10 27.3,78.23 20.95,78.23 C1.14 | v319.15,176.66 S1.3
  Bottom 1.016: 168.91,301.12 167.64,302.39 166.37,301.12 v166.37,298.83 166.37,298.58 | 207.01,301.12 208.28,302.39 | 245.11,301.12 246.38,302.39 | R12.2 R14.2 R16.2 R18.2 R20.2 R22.2 R24.2 R26.2 | R25.2 R23.2 R21.2 R19.2 R17.2 R15.2 R13.2 R11.2 | R52.2 R51.2 R50.2 R49.2 R48.2 R47.2 R46.2 R45.2 | R42.2 R40.2 R38.2 R36.2 R34.2 R32.2 R30.2 R28.2 | R41.2 R39.2 R37.2 R35.2 R33.2 R31.2 R29.2 R27.2 | 280.67,302.39 v280.67,298.83 280.67,298.58 | 318.77,302.39 v318.77,298.83 318.77,298.58 | 242.57,302.39 v242.57,298.83 242.57,298.58 | 204.47,302.39 v204.47,298.83 204.47,298.58 | 128.27,302.39 v128.27,298.83 128.27,298.58 | 90.17,302.39 v90.17,298.83 90.17,298.58 | 52.07,302.39 v52.07,298.83 52.07,298.58 | 16.51,302.39 v16.51,298.83 16.51,298.58 | R54.2 R56.2 R58.2 R60.2 R62.2 R64.2 R66.2 R68.2 | R53.2 R55.2 R57.2 R59.2 R61.2 R63.2 R65.2 R67.2
  Bottom 2.54: P1.C v360.93,185.55 P1.D
  Bottom 5.08: v360.93,185.55 351.28,185.55 351.28,294.77 343.66,302.39 318.77,302.39 280.67,302.39 246.38,302.39 242.57,302.39 208.28,302.39 204.47,302.39 167.64,302.39 128.27,302.39 90.17,302.39 52.07,302.39 16.51,302.39 11.43,302.39
VISIBLE  (via drill 0.35)
  Top 0.508: A8.2 v288.29,27.81 287.02,29.08 287.02,44.58 B8.2
  Bottom 0.508: A8.2 290.19,21.08 294,21.08 A8.5 | A7.13 252.98,27.81 v288.29,27.81
VISIBLETORPEDO  (via drill 0.35)
  Top 0.508: v164.34,174.62 164.34,110.74 | 164.34,110.74 v164.34,89.66 | v164.47,110.74 164.34,110.74 | H5.10 180.34,193.17 180.34,174.12 G5.11
  Bottom 0.508: D4.5 145.41,89.66 v164.34,89.66 | v164.34,174.62 164.47,174.75 177.16,174.75 G5.11 | E7.5 254.13,110.74 v164.47,110.74
VRESET  (via drill 0.35)
  Top 0.508: G1.2 22.86,166.5 v22.86,181.86 | I2.8 71.12,217.3 71.12,204.47 63.5,196.85 63.5,191.13 62.23,189.86 H2.3 | v259.46,50.55 260.35,51.44 B7.9 | v124.59,56.26 v124.59,184.66
  Bottom 0.508: v22.86,181.86 21.59,183.13 21.59,186.18 | 21.59,186.18 H1.2 H1.3 | H2.3 H2.2 57.78,186.18 | 57.78,186.18 21.59,186.18 | v259.46,50.55 148.97,50.55 B4.9 143.38,56.13 124.71,56.13 v124.59,56.26 | 57.78,186.18 59.31,184.66 v124.59,184.66
VSYNC  (via drill 0.35)
  Top 0.508: v125.48,89.66 v125.48,162.56
  Bottom 0.508: G3.2 100.46,162.56 v125.48,162.56 | v125.48,89.66 139.06,89.66 D4.4

## Text on the board
Top: L | K | J | Sound Level | PERISCOPE | + | - | I | REV - C | (c) Kincaid Arcade | 2018 | KincaidArcade.com | Game Time | Engineered By: | H | - | + | Alexander H. | (A 15 Year Old!) | 2 | 1 | Games Given / Per Coin | G | F | E | D | C | B | A | 1 | 2 | 3 | 4 | 5 | 6 | 7 | 8 | 9
Bottom: L | K | J | I | H | G | F | E | D | C | B | A | 1 | 2 | 3 | 4 | 5 | 6 | 7 | 8 | 9